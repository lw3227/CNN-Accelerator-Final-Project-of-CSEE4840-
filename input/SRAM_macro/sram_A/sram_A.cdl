* 
* Copyright 2026 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.4.15
* Version: r0p0-00eac0
* Name: sram_sp_hdc_svt_rvt_hvt Compiler|TSMC cln65gplus 65nm Process, 0.525um2 Bitcell
* Comment: sram_A
* Configuration:  -instname "sram_A" -words 1024 -bits 32 -frequenc\
* Configuration: y 100 -mux 8 -pipeline off -write_mask off -wp_siz\
* Configuration: e 8 -write_thru on -top_layer "m5-m9" -power_type \
* Configuration: otc -redundancy off -rcols 2 -rrows 2 -bmux off -s\
* Configuration: er none -back_biasing off -power_gating off -reten\
* Configuration: tion on -ema on -atf off -cust_comment "sram_A" -b\
* Configuration: us_notation on -left_bus_delim "[" -right_bus_deli\
* Configuration: m "]" -pwr_gnd_rename "VDDPE:VDD,VDDCE:VDD,VSSE:VS\
* Configuration: S" -prefix "" -name_case upper -check_instname on \
* Configuration: -diodes on -drive 6 -dnw off -asvm on -corners tt_\
* Configuration: 1p00v_1p00v_25c,ss_0p90v_0p90v_m40c,ss_0p90v_0p90v\
* Configuration: _125c,ff_1p10v_1p10v_m40c,ff_1p10v_1p10v_125c,ff_1\
* Configuration: p10v_1p10v_0c
* Codefile: 
* 
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT sram_AFPIO8 BWEI BWEN CREN D DNI Q Q_ RET RETN_TERM TIEHIGH TIELOW VSS
+  VDD
** sram_AFPIO8: 11 flat devices **
D10 VSS Q NDIO 1.024e-07U 1.28U $name=/D4
D7 VSS BWEN NDIO 1.024e-07U 1.28U $name=/D7
D8 VSS D NDIO 1.024e-07U 1.28U $name=/D6
D9 VSS CREN NDIO 1.024e-07U 1.28U $name=/D5
M0 Q Q_ VSS VSS NCH W=2.8U L=0.06U M=1 $name=/qdrv/N00
M1 VDD Q_ Q VDD PCH W=4.14U L=0.06U M=1 $name=/qdrv/P00
M2 Q RET VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M3 DNI D VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/I238/N00
M4 VDD D DNI VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/I238/P00
M5 BWEI BWEN VSS VSS NCH_HVT W=0.25U L=0.06U M=1 $name=/I237/N00
M6 VDD BWEN BWEI VDD PCH_HVT W=0.5U L=0.06U M=1 $name=/I237/P00
.ENDS sram_AFPIO8
****
.SUBCKT sram_AFPIO8RR16 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6
+  BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 BWEN
+  CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10
+  DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9
+  D_10 D_11 D_12 D_13 D_14 D_15 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10
+  Q_11 Q_12 Q_13 Q_14 Q_15 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9
+  Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 RETN_TERM_0 RETN_TERM_1 RETN_TERM_2
+  RETN_TERM_3 RETN_TERM_4 RETN_TERM_5 RETN_TERM_6 RETN_TERM_7 RETN_TERM_8
+  RETN_TERM_9 RETN_TERM_10 RETN_TERM_11 RETN_TERM_12 RETN_TERM_13
+  RETN_TERM_14 RETN_TERM_15 RET_0 RET_1 RET_2 RET_3 RET_4 RET_5 RET_6 RET_7
+  RET_8 RET_9 RET_10 RET_11 RET_12 RET_13 RET_14 RET_15 VSS VDD
** sram_AFPIO8RR16: 176 flat devices **
XRIGHTIO0 BWEI_0 BWEN CREN D_0 DNI_0 Q_0 Q__0 RET_0 RETN_TERM_0 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO1 BWEI_1 BWEN CREN D_1 DNI_1 Q_1 Q__1 RET_1 RETN_TERM_1 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO10 BWEI_10 BWEN CREN D_10 DNI_10 Q_10 Q__10 RET_10 RETN_TERM_10 CREN
+  BWEN VSS VDD sram_AFPIO8
XRIGHTIO11 BWEI_11 BWEN CREN D_11 DNI_11 Q_11 Q__11 RET_11 RETN_TERM_11 CREN
+  BWEN VSS VDD sram_AFPIO8
XRIGHTIO12 BWEI_12 BWEN CREN D_12 DNI_12 Q_12 Q__12 RET_12 RETN_TERM_12 CREN
+  BWEN VSS VDD sram_AFPIO8
XRIGHTIO13 BWEI_13 BWEN CREN D_13 DNI_13 Q_13 Q__13 RET_13 RETN_TERM_13 CREN
+  BWEN VSS VDD sram_AFPIO8
XRIGHTIO14 BWEI_14 BWEN CREN D_14 DNI_14 Q_14 Q__14 RET_14 RETN_TERM_14 CREN
+  BWEN VSS VDD sram_AFPIO8
XRIGHTIO2 BWEI_2 BWEN CREN D_2 DNI_2 Q_2 Q__2 RET_2 RETN_TERM_2 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO3 BWEI_3 BWEN CREN D_3 DNI_3 Q_3 Q__3 RET_3 RETN_TERM_3 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO4 BWEI_4 BWEN CREN D_4 DNI_4 Q_4 Q__4 RET_4 RETN_TERM_4 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO5 BWEI_5 BWEN CREN D_5 DNI_5 Q_5 Q__5 RET_5 RETN_TERM_5 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO6 BWEI_6 BWEN CREN D_6 DNI_6 Q_6 Q__6 RET_6 RETN_TERM_6 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO7 BWEI_7 BWEN CREN D_7 DNI_7 Q_7 Q__7 RET_7 RETN_TERM_7 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO8 BWEI_8 BWEN CREN D_8 DNI_8 Q_8 Q__8 RET_8 RETN_TERM_8 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIO9 BWEI_9 BWEN CREN D_9 DNI_9 Q_9 Q__9 RET_9 RETN_TERM_9 CREN BWEN VSS
+  VDD sram_AFPIO8
XRIGHTIOEXT15 BWEI_15 BWEN CREN D_15 DNI_15 Q_15 Q__15 RET_15 RETN_TERM_15
+  CREN BWEN VSS VDD sram_AFPIO8
.ENDS sram_AFPIO8RR16
****
.SUBCKT sram_AFPAL_CTRL AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4 AI4N AI5 AI5N
+  AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12 AI12N AI13
+  AI13N BWEN CEI CEN CLK EMA0 EMA1 EMA2 IRET IRETN RDT RETN STOV TIEHIGH
+  TIELOW WBT WEI WEN VSS VDD
** sram_AFPAL_CTRL: 54 flat devices **
D10 VSS CLK NDIO 1.024e-07U 1.28U $name=/I2449/D1
D11 VSS CEN NDIO 1.024e-07U 1.28U $name=/I2449/D0
D4 VSS STOV NDIO 1.024e-07U 1.28U $name=/I2449/D7
D40 VSS AI5 NDIO 1.024e-07U 1.28U $name=/I2450/D9
D41 VSS AI4 NDIO 1.024e-07U 1.28U $name=/I2450/D8
D42 VSS AI6 NDIO 1.024e-07U 1.28U $name=/I2450/D7
D43 VSS AI7 NDIO 1.024e-07U 1.28U $name=/I2450/D6
D44 VSS AI9 NDIO 1.024e-07U 1.28U $name=/I2450/D5
D45 VSS AI8 NDIO 1.024e-07U 1.28U $name=/I2450/D4
D46 VSS AI10 NDIO 1.024e-07U 1.28U $name=/I2450/D3
D47 VSS AI11 NDIO 1.024e-07U 1.28U $name=/I2450/D2
D48 VSS AI1 NDIO 1.024e-07U 1.28U $name=/I2450/D13
D49 VSS AI0 NDIO 1.024e-07U 1.28U $name=/I2450/D12
D5 VSS EMA0 NDIO 1.024e-07U 1.28U $name=/I2449/D6
D50 VSS AI2 NDIO 1.024e-07U 1.28U $name=/I2450/D11
D51 VSS AI3 NDIO 1.024e-07U 1.28U $name=/I2450/D10
D52 VSS AI12 NDIO 1.024e-07U 1.28U $name=/I2450/D1
D53 VSS AI13 NDIO 1.024e-07U 1.28U $name=/I2450/D0
D6 VSS RETN NDIO 1.024e-07U 1.28U $name=/I2449/D3
D7 VSS WEN NDIO 1.024e-07U 1.28U $name=/I2449/D2
D8 VSS WBT NDIO 1.024e-07U 1.28U $name=/I2449/D12
D9 VSS RDT NDIO 1.024e-07U 1.28U $name=/I2449/D11
M0 WEI WEN VSS VSS NCH W=1.68U L=0.06U M=1 $name=/I2449/tnorwece/N00
M1 VDD WEN WEI VDD PCH W=2.3U L=0.06U M=1 $name=/I2449/tnorwece/P00
M12 AI7N AI7 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I9/N00
M13 VDD AI7 AI7N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I9/P00
M14 AI6N AI6 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I8/N00
M15 VDD AI6 AI6N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I8/P00
M16 AI5N AI5 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I7/N00
M17 VDD AI5 AI5N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I7/P00
M18 AI0N AI0 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I60/N00
M19 VDD AI0 AI0N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I60/P00
M2 CEI CEN VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I2449/tceninv/N00
M20 AI2N AI2 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I4/N00
M21 VDD AI2 AI2N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I4/P00
M22 AI1N AI1 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I3/N00
M23 VDD AI1 AI1N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I3/P00
M24 AI13N AI13 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I15/N00
M25 VDD AI13 AI13N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I15/P00
M26 AI12N AI12 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I14/N00
M27 VDD AI12 AI12N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I14/P00
M28 AI11N AI11 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I13/N00
M29 VDD AI11 AI11N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I13/P00
M3 VDD CEN CEI VDD PCH W=0.15U L=0.06U M=1 $name=/I2449/tceninv/P00
M30 AI10N AI10 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I12/N00
M31 VDD AI10 AI10N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I12/P00
M32 AI9N AI9 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I11/N00
M33 VDD AI9 AI9N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I11/P00
M34 AI8N AI8 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I10/N00
M35 VDD AI8 AI8N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I10/P00
M36 AI3N AI3 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I1/N00
M37 VDD AI3 AI3N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I1/P00
M38 AI4N AI4 VSS VSS NCH W=1.12U L=0.06U M=1 $name=/I2450/I0/N00
M39 VDD AI4 AI4N VDD PCH W=2.24U L=0.06U M=1 $name=/I2450/I0/P00
.ENDS sram_AFPAL_CTRL
****
.SUBCKT sram_AFPBCTRL32M8 AI0 AI0N AI1 AI1N AI2 AI2N AI3N AI4N AI5 AI5N AI6
+  AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12N AI13N CEI CEN
+  CLK EMA0 EMA1 EMA2 IRET IRETN RETN TIEHIGH TIELOW WEI WEN VSS VDD
** sram_AFPBCTRL32M8: 54 flat devices **
XINSTCTRL AI0 AI0N AI1 AI1N AI2 AI2N TIELOW AI3N TIELOW AI4N AI5 AI5N AI6 AI6N
+  AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N TIELOW AI12N TIELOW AI13N
+  TIELOW CEI CEN CLK EMA0 EMA1 EMA2 IRET IRETN TIELOW RETN TIELOW TIEHIGH
+  TIELOW TIELOW WEI WEN VSS VDD sram_AFPAL_CTRL
.ENDS sram_AFPBCTRL32M8
****
.SUBCKT sram_AFPIO8RL16 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6
+  BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 BWEN
+  CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10
+  DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9
+  D_10 D_11 D_12 D_13 D_14 D_15 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10
+  Q_11 Q_12 Q_13 Q_14 Q_15 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9
+  Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 RETN_TERM_0 RETN_TERM_1 RETN_TERM_2
+  RETN_TERM_3 RETN_TERM_4 RETN_TERM_5 RETN_TERM_6 RETN_TERM_7 RETN_TERM_8
+  RETN_TERM_9 RETN_TERM_10 RETN_TERM_11 RETN_TERM_12 RETN_TERM_13
+  RETN_TERM_14 RETN_TERM_15 RET_0 RET_1 RET_2 RET_3 RET_4 RET_5 RET_6 RET_7
+  RET_8 RET_9 RET_10 RET_11 RET_12 RET_13 RET_14 RET_15 VSS VDD
** sram_AFPIO8RL16: 176 flat devices **
XLEFTIO0 BWEI_0 BWEN CREN D_0 DNI_0 Q_0 Q__0 RET_0 RETN_TERM_0 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO1 BWEI_1 BWEN CREN D_1 DNI_1 Q_1 Q__1 RET_1 RETN_TERM_1 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO10 BWEI_10 BWEN CREN D_10 DNI_10 Q_10 Q__10 RET_10 RETN_TERM_10 CREN
+  BWEN VSS VDD sram_AFPIO8
XLEFTIO11 BWEI_11 BWEN CREN D_11 DNI_11 Q_11 Q__11 RET_11 RETN_TERM_11 CREN
+  BWEN VSS VDD sram_AFPIO8
XLEFTIO12 BWEI_12 BWEN CREN D_12 DNI_12 Q_12 Q__12 RET_12 RETN_TERM_12 CREN
+  BWEN VSS VDD sram_AFPIO8
XLEFTIO13 BWEI_13 BWEN CREN D_13 DNI_13 Q_13 Q__13 RET_13 RETN_TERM_13 CREN
+  BWEN VSS VDD sram_AFPIO8
XLEFTIO14 BWEI_14 BWEN CREN D_14 DNI_14 Q_14 Q__14 RET_14 RETN_TERM_14 CREN
+  BWEN VSS VDD sram_AFPIO8
XLEFTIO2 BWEI_2 BWEN CREN D_2 DNI_2 Q_2 Q__2 RET_2 RETN_TERM_2 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO3 BWEI_3 BWEN CREN D_3 DNI_3 Q_3 Q__3 RET_3 RETN_TERM_3 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO4 BWEI_4 BWEN CREN D_4 DNI_4 Q_4 Q__4 RET_4 RETN_TERM_4 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO5 BWEI_5 BWEN CREN D_5 DNI_5 Q_5 Q__5 RET_5 RETN_TERM_5 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO6 BWEI_6 BWEN CREN D_6 DNI_6 Q_6 Q__6 RET_6 RETN_TERM_6 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO7 BWEI_7 BWEN CREN D_7 DNI_7 Q_7 Q__7 RET_7 RETN_TERM_7 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO8 BWEI_8 BWEN CREN D_8 DNI_8 Q_8 Q__8 RET_8 RETN_TERM_8 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIO9 BWEI_9 BWEN CREN D_9 DNI_9 Q_9 Q__9 RET_9 RETN_TERM_9 CREN BWEN VSS
+  VDD sram_AFPIO8
XLEFTIOEXT15 BWEI_15 BWEN CREN D_15 DNI_15 Q_15 Q__15 RET_15 RETN_TERM_15 CREN
+  BWEN VSS VDD sram_AFPIO8
.ENDS sram_AFPIO8RL16
****
.SUBCKT sram_ABR32FPIO8 AI0 AI0N AI1 AI1N AI2 AI2N AI3N AI4N AI5 AI5N AI6 AI6N
+  AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12N AI13N BWEI_0 BWEI_1
+  BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11
+  BWEI_12 BWEI_13 BWEI_14 BWEI_15 BWEI_16 BWEI_17 BWEI_18 BWEI_19 BWEI_20
+  BWEI_21 BWEI_22 BWEI_23 BWEI_24 BWEI_25 BWEI_26 BWEI_27 BWEI_28 BWEI_29
+  BWEI_30 BWEI_31 CEI CEN CLK CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6
+  DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 DNI_16 DNI_17
+  DNI_18 DNI_19 DNI_20 DNI_21 DNI_22 DNI_23 DNI_24 DNI_25 DNI_26 DNI_27
+  DNI_28 DNI_29 DNI_30 DNI_31 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10
+  D_11 D_12 D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 D_21 D_22 D_23 D_24 D_25
+  D_26 D_27 D_28 D_29 D_30 D_31 EMA0 EMA1 EMA2 IRET IRETN Q_0 Q_1 Q_2 Q_3 Q_4
+  Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q_16 Q_17 Q_18 Q_19 Q_20
+  Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27 Q_28 Q_29 Q_30 Q_31 Q__0 Q__1 Q__2 Q__3
+  Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 Q__16
+  Q__17 Q__18 Q__19 Q__20 Q__21 Q__22 Q__23 Q__24 Q__25 Q__26 Q__27 Q__28
+  Q__29 Q__30 Q__31 RETN RETN_TERM_0 RETN_TERM_1 RETN_TERM_2 RETN_TERM_3
+  RETN_TERM_4 RETN_TERM_5 RETN_TERM_6 RETN_TERM_7 RETN_TERM_8 RETN_TERM_9
+  RETN_TERM_10 RETN_TERM_11 RETN_TERM_12 RETN_TERM_13 RETN_TERM_14
+  RETN_TERM_15 RETN_TERM_16 RETN_TERM_17 RETN_TERM_18 RETN_TERM_19
+  RETN_TERM_20 RETN_TERM_21 RETN_TERM_22 RETN_TERM_23 RETN_TERM_24
+  RETN_TERM_25 RETN_TERM_26 RETN_TERM_27 RETN_TERM_28 RETN_TERM_29
+  RETN_TERM_30 RETN_TERM_31 RET_0 RET_1 RET_2 RET_3 RET_4 RET_5 RET_6 RET_7
+  RET_8 RET_9 RET_10 RET_11 RET_12 RET_13 RET_14 RET_15 RET_16 RET_17 RET_18
+  RET_19 RET_20 RET_21 RET_22 RET_23 RET_24 RET_25 RET_26 RET_27 RET_28
+  RET_29 RET_30 RET_31 TIELOW WEI WEN VSS VDD
** sram_ABR32FPIO8: 406 flat devices **
XBOTCTRL AI0 AI0N AI1 AI1N AI2 AI2N AI3N AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8
+  AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12N AI13N CEI CEN CLK EMA0 EMA1 EMA2
+  IRET IRETN RETN CREN TIELOW WEI WEN VSS VDD sram_AFPBCTRL32M8
XLEFTIOROW BWEI_15 BWEI_14 BWEI_13 BWEI_12 BWEI_11 BWEI_10 BWEI_9 BWEI_8
+  BWEI_7 BWEI_6 BWEI_5 BWEI_4 BWEI_3 BWEI_2 BWEI_1 BWEI_0 TIELOW CREN DNI_15
+  DNI_14 DNI_13 DNI_12 DNI_11 DNI_10 DNI_9 DNI_8 DNI_7 DNI_6 DNI_5 DNI_4
+  DNI_3 DNI_2 DNI_1 DNI_0 D_15 D_14 D_13 D_12 D_11 D_10 D_9 D_8 D_7 D_6 D_5
+  D_4 D_3 D_2 D_1 D_0 Q_15 Q_14 Q_13 Q_12 Q_11 Q_10 Q_9 Q_8 Q_7 Q_6 Q_5 Q_4
+  Q_3 Q_2 Q_1 Q_0 Q__15 Q__14 Q__13 Q__12 Q__11 Q__10 Q__9 Q__8 Q__7 Q__6
+  Q__5 Q__4 Q__3 Q__2 Q__1 Q__0 RETN_TERM_15 RETN_TERM_14 RETN_TERM_13
+  RETN_TERM_12 RETN_TERM_11 RETN_TERM_10 RETN_TERM_9 RETN_TERM_8 RETN_TERM_7
+  RETN_TERM_6 RETN_TERM_5 RETN_TERM_4 RETN_TERM_3 RETN_TERM_2 RETN_TERM_1
+  RETN_TERM_0 RET_15 RET_14 RET_13 RET_12 RET_11 RET_10 RET_9 RET_8 RET_7
+  RET_6 RET_5 RET_4 RET_3 RET_2 RET_1 RET_0 VSS VDD sram_AFPIO8RL16
XRIGHTIOROW BWEI_16 BWEI_17 BWEI_18 BWEI_19 BWEI_20 BWEI_21 BWEI_22 BWEI_23
+  BWEI_24 BWEI_25 BWEI_26 BWEI_27 BWEI_28 BWEI_29 BWEI_30 BWEI_31 TIELOW CREN
+  DNI_16 DNI_17 DNI_18 DNI_19 DNI_20 DNI_21 DNI_22 DNI_23 DNI_24 DNI_25
+  DNI_26 DNI_27 DNI_28 DNI_29 DNI_30 DNI_31 D_16 D_17 D_18 D_19 D_20 D_21
+  D_22 D_23 D_24 D_25 D_26 D_27 D_28 D_29 D_30 D_31 Q_16 Q_17 Q_18 Q_19 Q_20
+  Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27 Q_28 Q_29 Q_30 Q_31 Q__16 Q__17 Q__18
+  Q__19 Q__20 Q__21 Q__22 Q__23 Q__24 Q__25 Q__26 Q__27 Q__28 Q__29 Q__30
+  Q__31 RETN_TERM_16 RETN_TERM_17 RETN_TERM_18 RETN_TERM_19 RETN_TERM_20
+  RETN_TERM_21 RETN_TERM_22 RETN_TERM_23 RETN_TERM_24 RETN_TERM_25
+  RETN_TERM_26 RETN_TERM_27 RETN_TERM_28 RETN_TERM_29 RETN_TERM_30
+  RETN_TERM_31 RET_16 RET_17 RET_18 RET_19 RET_20 RET_21 RET_22 RET_23 RET_24
+  RET_25 RET_26 RET_27 RET_28 RET_29 RET_30 RET_31 VSS VDD sram_AFPIO8RR16
.ENDS sram_ABR32FPIO8
****
.SUBCKT sram_AIO8 BLTERM0 BLTERM0_ BLTERM1 BLTERM1_ BLTERM2 BLTERM2_ BLTERM3
+  BLTERM3_ BLTERM4 BLTERM4_ BLTERM5 BLTERM5_ BLTERM6 BLTERM6_ BLTERM7
+  BLTERM7_ BWEI CE_WE CREN CRENA CRENB CRENI DNI FIOGTP GDL GDLA GDLA_ GDLB
+  GDLB_ GDLI GDLI_ GDL_ IODL IODL_ IOGTP IRET IRETN Q_ RDEN TIEHIGH TIELOW WE
+  WEA WEB WEI YI YP1_0 YP1_1 YP1_2 YP1_3 YSN YSNA YSNB YSNI VSS VDD
** sram_AIO8: 172 flat devices **
M0 NET575 NET339 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/tiginvpredrv/N10
M1 NET575 RDEN VSS VSS NCH W=0.2U L=0.06U M=1 $name=/tiginvpredrv/N00
M10 VDD NET615 NET477 VDD PCH W=0.83U L=0.06U M=1 $name=/tiogdlprech/P10
M100 NET550 NET408 VSS VSS NCH W=0.4U L=0.06U M=1 $name=/N43/N00
M101 NET384 NET362 WE VSS NCH W=1U L=0.06U M=1 $name=/N4/N00
M102 VSS NET550 IODL_ VSS NCH W=3U L=0.06U M=1 $name=/N38/N00
M103 GDL NET537 IODL VSS NCH W=3U L=0.06U M=1 $name=/N3/N00
M104 IODL NET540 GDLI VSS NCH W=3U L=0.06U M=1 $name=/N2/N00
M105 NET545 QIE_N VSS VSS NCH W=2.17U L=0.06U M=1 $name=/N17/N00
M106 IODW WE NET547 VSS NCH W=1.5U L=0.06U M=1 $name=/N12/N00
M107 IODW WE NET550 VSS NCH W=1.5U L=0.06U M=1 $name=/N11/N00
M108 IODL_ NET537 GDL_ VSS NCH W=3U L=0.06U M=1 $name=/N10/N00
M109 IODL_ NET540 GDLI_ VSS NCH W=3U L=0.06U M=1 $name=/N0/N00
M11 VDD IOGTPD NET477 VDD PCH W=0.83U L=0.06U M=1 $name=/tiogdlprech/P00
M110 HNET371 CREN VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/I244/N01
M111 NET559 CRENI HNET371 VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/I244/N00
M112 VDD CREN NET559 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/I244/P10
M113 VDD CRENI NET559 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/I244/P00
M114 YILOUT NET351 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I3/N00
M115 VDD NET351 YILOUT VDD PCH W=0.3U L=0.06U M=1 $name=/I3/P00
M116 NET563 YI VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M117 VDD YI NET563 VDD PCH W=0.15U L=0.06U M=1 $name=/I1/P00
M118 WE WELOUTN VSS VSS NCH W=2U L=0.06U M=1 $name=/weidrv/N00
M119 VDD WELOUTN WE VDD PCH W=4U L=0.06U M=1 $name=/weidrv/P00
M12 HNET143 NET591 VSS VSS NCH W=0.75U L=0.06U M=1 $name=/tgtpnd2/N01
M120 NET567 BWEI VSS VSS NCH W=0.18U L=0.06U M=1 $name=/tweinv/N00
M121 VDD BWEI NET567 VDD PCH W=0.33U L=0.06U M=1 $name=/tweinv/P00
M122 NET569 IODL_ VSS VSS NCH W=0.36U L=0.06U M=1 $name=/tqbpu2drv/N00
M123 VDD IODL_ NET569 VDD PCH W=0.7U L=0.06U M=1 $name=/tqbpu2drv/P00
M124 QILAT Q_ VSS VSS NCH W=0.24U L=0.06U M=1 $name=/tqbfbinv/N00
M125 VDD Q_ QILAT VDD PCH W=0.47U L=0.06U M=1 $name=/tqbfbinv/P00
M126 QIE_N QIE_P VSS VSS NCH W=0.36U L=0.06U M=1 $name=/tlinv/N00
M127 VDD QIE_P QIE_N VDD PCH W=0.49U L=0.06U M=1 $name=/tlinv/P00
M128 QIE_P NET575 VSS VSS NCH W=0.62U L=0.06U M=1 $name=/tiginv/N00
M129 VDD NET575 QIE_P VDD PCH W=1.2U L=0.06U M=1 $name=/tiginv/P00
M13 IOGTPD QIE_P HNET143 VSS NCH W=0.75U L=0.06U M=1 $name=/tgtpnd2/N00
M130 NET579 IOGTPD VSS VSS NCH W=0.25U L=0.06U M=1 $name=/tgtpn/N00
M131 VDD IOGTPD NET579 VDD PCH W=0.56U L=0.06U M=1 $name=/tgtpn/P00
M132 NET581 NET619 VSS VSS NCH W=0.18U L=0.06U M=1 $name=/tdinv/N00
M133 VDD NET619 NET581 VDD PCH W=0.33U L=0.06U M=1 $name=/tdinv/P00
M134 NET583 DNI VSS VSS NCH W=0.18U L=0.06U M=1 $name=/tdininv/N00
M135 VDD DNI NET583 VDD PCH W=0.33U L=0.06U M=1 $name=/tdininv/P00
M136 YSEL YSN VSS VSS NCH W=0.6U L=0.06U M=1 $name=/gyselinv/N00
M137 VDD YSN YSEL VDD PCH W=0.6U L=0.06U M=1 $name=/gyselinv/P00
M138 WELOUTN WELOUT VSS VSS NCH W=1U L=0.06U M=1 $name=/gwelat/N00
M139 VDD WELOUT WELOUTN VDD PCH W=1.4U L=0.06U M=1 $name=/gwelat/P00
M14 VDD NET591 IOGTPD VDD PCH W=0.74U L=0.06U M=1 $name=/tgtpnd2/P10
M140 WEIN NET330 VSS VSS NCH W=0.5U L=0.06U M=1 $name=/gwdly/N00
M141 VDD NET330 WEIN VDD PCH W=0.82U L=0.06U M=1 $name=/gwdly/P00
M142 NET591 IOGTP VSS VSS NCH W=0.15U L=0.06U M=1 $name=/gtp/N00
M143 VDD IOGTP NET591 VDD PCH W=0.15U L=0.06U M=1 $name=/gtp/P00
M144 NET540 NET348 VSS VSS NCH W=0.5U L=0.06U M=1 $name=/gpginv/N00
M145 VDD NET348 NET540 VDD PCH W=1U L=0.06U M=1 $name=/gpginv/P00
M146 YSN YILOUT VSS VSS NCH W=0.5U L=0.06U M=1 $name=/gpgdrv2/N00
M147 VDD YILOUT YSN VDD PCH W=1U L=0.06U M=1 $name=/gpgdrv2/P00
M148 NET597 NET509 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/gpgdrv1/N00
M149 VDD NET509 NET597 VDD PCH W=0.3U L=0.06U M=1 $name=/gpgdrv1/P00
M15 VDD QIE_P IOGTPD VDD PCH W=0.74U L=0.06U M=1 $name=/tgtpnd2/P00
M150 NET537 NET345 VSS VSS NCH W=0.5U L=0.06U M=1 $name=/gnreg/N00
M151 VDD NET345 NET537 VDD PCH W=1U L=0.06U M=1 $name=/gnreg/P00
M152 NET408 WE VSS VSS NCH W=1.1U L=0.06U M=1 $name=/geninv/N00
M153 VDD WE NET408 VDD PCH W=2.8U L=0.06U M=1 $name=/geninv/P00
M154 IODW DLOUTN VSS VSS NCH W=1U L=0.06U M=1 $name=/gdndrv/N00
M155 VDD DLOUTN IODW VDD PCH W=2U L=0.06U M=1 $name=/gdndrv/P00
M156 DLOUTN DLOUT VSS VSS NCH W=0.8U L=0.06U M=1 $name=/gdlat/N00
M157 VDD DLOUT DLOUTN VDD PCH W=1.97U L=0.06U M=1 $name=/gdlat/P00
M158 NET607 DLOUTN VSS VSS NCH W=0.58U L=0.06U M=1 $name=/gddrvb/N00
M159 VDD DLOUTN NET607 VDD PCH W=1.14U L=0.06U M=1 $name=/gddrvb/P00
M16 HNET147 IOGTP VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N01
M160 IODW_ NET607 VSS VSS NCH W=1U L=0.06U M=1 $name=/gddrv/N00
M161 VDD NET607 IODW_ VDD PCH W=2U L=0.06U M=1 $name=/gddrv/P00
M162 DIN NET613 VSS VSS NCH W=0.5U L=0.06U M=1 $name=/gddly2/N00
M163 VDD NET613 DIN VDD PCH W=1U L=0.06U M=1 $name=/gddly2/P00
M164 NET613 NET581 VSS VSS NCH W=0.18U L=0.06U M=1 $name=/gddly/N00
M165 VDD NET581 NET613 VDD PCH W=0.33U L=0.06U M=1 $name=/gddly/P00
M166 NET615 FIOGTP VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I34/N00
M167 VDD FIOGTP NET615 VDD PCH W=0.15U L=0.06U M=1 $name=/I34/P00
M168 NET617 NET567 VSS VSS NCH W=0.18U L=0.06U M=1 $name=/I12/N00
M169 VDD NET567 NET617 VDD PCH W=0.33U L=0.06U M=1 $name=/I12/P00
M17 NET339 NET615 HNET147 VSS NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N00
M170 NET619 NET583 VSS VSS NCH W=0.18U L=0.06U M=1 $name=/I10/N00
M171 VDD NET583 NET619 VDD PCH W=0.33U L=0.06U M=1 $name=/I10/P00
M18 VDD IOGTP NET339 VDD PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P10
M19 VDD NET615 NET339 VDD PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P00
M2 VDD NET339 HNET128 VDD PCH W=0.4U L=0.06U M=1 $name=/tiginvpredrv/P01
M20 HNET151 NET384 VSS VSS NCH W=1U L=0.06U M=1 $name=/gweio/N01
M21 NET342 NET597 HNET151 VSS NCH W=1U L=0.06U M=1 $name=/gweio/N00
M22 VDD NET384 NET342 VDD PCH W=0.8U L=0.06U M=1 $name=/gweio/P10
M23 VDD NET597 NET342 VDD PCH W=0.8U L=0.06U M=1 $name=/gweio/P00
M24 HNET155 NET362 VSS VSS NCH W=1U L=0.06U M=1 $name=/gpreg/N01
M25 NET345 YSEL HNET155 VSS NCH W=1U L=0.06U M=1 $name=/gpreg/N00
M26 VDD NET362 NET345 VDD PCH W=1U L=0.06U M=1 $name=/gpreg/P10
M27 VDD YSEL NET345 VDD PCH W=1U L=0.06U M=1 $name=/gpreg/P00
M28 HNET159 NET364 VSS VSS NCH W=1U L=0.06U M=1 $name=/gpnand/N01
M29 NET348 YSEL HNET159 VSS NCH W=1U L=0.06U M=1 $name=/gpnand/N00
M3 HNET128 RDEN NET575 VDD PCH W=0.4U L=0.06U M=1 $name=/tiginvpredrv/P00
M30 VDD NET364 NET348 VDD PCH W=1U L=0.06U M=1 $name=/gpnand/P10
M31 VDD YSEL NET348 VDD PCH W=1U L=0.06U M=1 $name=/gpnand/P00
M32 HNET166 YILOUT VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I2/NI00
M33 NET351 IOGTPD HNET166 VSS NCH W=0.15U L=0.06U M=1 $name=/I2/NE00
M34 HNET161 NET579 NET351 VDD PCH W=0.15U L=0.06U M=1 $name=/I2/PE00
M35 VDD YILOUT HNET161 VDD PCH W=0.15U L=0.06U M=1 $name=/I2/PI00
M36 HNET172 WELOUTN VSS VSS NCH W=0.15U L=0.06U M=1 $name=/gwelatfb/NI00
M37 WELOUT IOGTPD HNET172 VSS NCH W=0.15U L=0.06U M=1 $name=/gwelatfb/NE00
M38 HNET167 NET579 WELOUT VDD PCH W=0.15U L=0.06U M=1 $name=/gwelatfb/PE00
M39 VDD WELOUTN HNET167 VDD PCH W=0.15U L=0.06U M=1 $name=/gwelatfb/PI00
M4 HNET135 NET617 VSS VSS NCH W=0.25U L=0.06U M=1 $name=/wnand/N01
M40 HNET178 DLOUTN VSS VSS NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NI00
M41 DLOUT IOGTPD HNET178 VSS NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NE00
M42 HNET173 NET579 DLOUT VDD PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PE00
M43 VDD DLOUTN HNET173 VDD PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PI00
M44 NET362 NET559 VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/tcrend/N00
M45 VDD NET559 NET362 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/tcrend/P00
M46 NET364 NET362 VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/gcrendd/N00
M47 VDD NET362 NET364 VDD PCH_HVT W=0.3U L=0.06U M=1 $name=/gcrendd/P00
M48 Q_ IRETN VDD VDD PCH_HVT W=1.06U L=0.06U M=1 $name=/tqbpuretn/P00
M49 NET373 QILAT Q_ VDD PCH_HVT W=1.06U L=0.06U M=1 $name=/tqbpu2/P00
M5 NET330 CE_WE HNET135 VSS NCH W=0.25U L=0.06U M=1 $name=/wnand/N00
M50 VDD QIE_N NET373 VDD PCH_HVT W=1.06U L=0.06U M=1 $name=/P35/P00
M51 VDD NET569 NET373 VDD PCH_HVT W=1.06U L=0.06U M=1 $name=/P33/P00
M52 WELOUT IOGTPD WEIN VDD PCH W=0.49U L=0.06U M=1 $name=/wpgp/P00
M53 NET383 IODL Q_ VDD PCH W=2.13U L=0.06U M=1 $name=/tqbpu/P00
M54 VDD NET384 NET419 VDD PCH W=1U L=0.06U M=1 $name=/tpswitch/P00
M55 VDD NET477 GDLPRE VDD PCH W=1.5U L=0.06U M=1 $name=/tppreb/P00
M56 VDD NET342 GDLPRE VDD PCH W=1.5U L=0.06U M=1 $name=/tpprea/P00
M57 YSN NET364 NET509 VDD PCH W=0.2U L=0.06U M=1 $name=/tppg2/P00
M58 YSNI NET362 NET509 VDD PCH W=0.2U L=0.06U M=1 $name=/tppg1/P00
M59 NET351 IOGTPD NET563 VDD PCH W=0.2U L=0.06U M=1 $name=/tpgp2/P00
M6 VDD NET617 NET330 VDD PCH W=0.25U L=0.06U M=1 $name=/wnand/P10
M60 DLOUT IOGTPD DIN VDD PCH W=0.49U L=0.06U M=1 $name=/tpdpass/P00
M61 VDD WE NET406 VDD PCH W=1U L=0.06U M=1 $name=/tgdlpukp/P00
M62 NET406 NET408 IODW_ VDD PCH W=1.5U L=0.06U M=1 $name=/tgdlppgp/P00
M63 VDD GDLPRE GDL VDD PCH W=3U L=0.06U M=1 $name=/tgdlpch/P00
M64 NET518 NET408 IODW_ VDD PCH W=1.5U L=0.06U M=1 $name=/tgdlnpgp/P00
M65 NET419 GDL_ GDL VDD PCH W=1U L=0.06U M=1 $name=/tgdlkeeperio/P00
M66 GDL GDLPRE GDL_ VDD PCH W=3U L=0.06U M=1 $name=/tgdleq/P00
M67 IODL NET406 VDD VDD PCH W=5U L=0.06U M=1 $name=/tgdldrvp/P00
M68 NET419 GDL GDL_ VDD PCH W=1U L=0.06U M=1 $name=/tgdlbkeeper/P00
M69 NET550 NET408 IODW VDD PCH W=1.5U L=0.06U M=1 $name=/P7/P00
M7 VDD CE_WE NET330 VDD PCH W=0.25U L=0.06U M=1 $name=/wnand/P00
M70 WEI NET362 NET384 VDD PCH W=1U L=0.06U M=1 $name=/P6/P00
M71 VDD WE NET547 VDD PCH W=1U L=0.06U M=1 $name=/P55/P00
M72 WE NET364 NET384 VDD PCH W=1U L=0.06U M=1 $name=/P5/P00
M73 IODL_ NET547 VDD VDD PCH W=5U L=0.06U M=1 $name=/P43/P00
M74 GDL_ NET345 IODL_ VDD PCH W=3U L=0.06U M=1 $name=/P4/P00
M75 IODL NET345 GDL VDD PCH W=3U L=0.06U M=1 $name=/P3/P00
M76 VDD GDLPRE GDL_ VDD PCH W=3U L=0.06U M=1 $name=/P2/P00
M77 VDD QIE_P NET464 VDD PCH W=2.13U L=0.06U M=1 $name=/P18/P00
M78 VDD QIE_P NET383 VDD PCH W=2.13U L=0.06U M=1 $name=/P13/P00
M79 NET547 NET408 IODW VDD PCH W=1.5U L=0.06U M=1 $name=/P12/P00
M8 HNET139 NET615 VSS VSS NCH W=0.84U L=0.06U M=1 $name=/tiogdlprech/N01
M80 NET464 IODL Q_ VDD PCH W=2.13U L=0.06U M=1 $name=/P11/P00
M81 GDLI NET348 IODL VDD PCH W=3U L=0.06U M=1 $name=/P1/P00
M82 GDLI_ NET348 IODL_ VDD PCH W=3U L=0.06U M=1 $name=/P0/P00
M83 VSS IRETN NET490 VSS NCH_HVT W=1U L=0.06U M=1 $name=/tqbpdretn/N00
M84 Q_ QILAT NET491 VSS NCH_HVT W=1U L=0.06U M=1 $name=/tqbpd2/N00
M85 NET491 QIE_P NET490 VSS NCH_HVT W=1U L=0.06U M=1 $name=/N20/N00
M86 NET491 IODL NET490 VSS NCH_HVT W=1U L=0.06U M=1 $name=/N18/N00
M87 WEIN NET579 WELOUT VSS NCH W=0.5U L=0.06U M=1 $name=/wpgn/N00
M88 Q_ NET569 NET545 VSS NCH W=2.17U L=0.06U M=1 $name=/tqbpd/N00
M89 NET563 NET579 NET351 VSS NCH W=0.2U L=0.06U M=1 $name=/tpgn2/N00
M9 NET477 IOGTPD HNET139 VSS NCH W=0.84U L=0.06U M=1 $name=/tiogdlprech/N00
M90 NET481 NET477 VSS VSS NCH W=1.5U L=0.06U M=1 $name=/tnpreb/N00
M91 GDLPRE NET342 NET481 VSS NCH W=1.5U L=0.06U M=1 $name=/tnprea/N00
M92 NET509 NET362 YSN VSS NCH W=0.2U L=0.06U M=1 $name=/tnpg2/N00
M93 NET509 NET364 YSNI VSS NCH W=0.2U L=0.06U M=1 $name=/tnpg1/N00
M94 DIN NET579 DLOUT VSS NCH W=0.5U L=0.06U M=1 $name=/tndpass/N00
M95 IODW_ WE NET406 VSS NCH W=1.5U L=0.06U M=1 $name=/tgdlppgn/N00
M96 NET518 NET408 VSS VSS NCH W=0.4U L=0.06U M=1 $name=/tgdlpdkp/N00
M97 IODW_ WE NET518 VSS NCH W=1.5U L=0.06U M=1 $name=/tgdlnpgn/N00
M98 VSS NET518 IODL VSS NCH W=3U L=0.06U M=1 $name=/tgdldrvn/N00
M99 NET384 NET364 WEI VSS NCH W=1U L=0.06U M=1 $name=/N9/N00
.ENDS sram_AIO8
****
.SUBCKT sram_AIO8EDGE CE_WE_TERM CRENA_TERM FIOGTP_TERM GDLA_TERM GDLA__TERM
+  IOGTP_TERM IRETN_TERM IRET_TERM PG_TERM TIEHIGH TIELOW TIELOW_TERM WE_TERM
+  YP0_TERM YP1_TERM YP2_TERM YP3_TERM YSNA_TERM VSS VDD
** sram_AIO8EDGE: 4 flat devices **
M0 VDD TIEHIGH TIEHIGH VDD PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M1 VDD TIELOW TIEHIGH VDD PCH W=4.9U L=0.06U M=1 $name=/P0/P00
M2 TIELOW TIEHIGH VSS VSS NCH W=3.15U L=0.06U M=1 $name=/tioarefn/N00
M3 TIELOW TIELOW VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N3/N00
.ENDS sram_AIO8EDGE
****
.SUBCKT sram_AIO8RR16 BLTERM0_0 BLTERM0_1 BLTERM0_2 BLTERM0_3 BLTERM0_4
+  BLTERM0_5 BLTERM0_6 BLTERM0_7 BLTERM0_8 BLTERM0_9 BLTERM0_10 BLTERM0_11
+  BLTERM0_12 BLTERM0_13 BLTERM0_14 BLTERM0_15 BLTERM0__0 BLTERM0__1
+  BLTERM0__2 BLTERM0__3 BLTERM0__4 BLTERM0__5 BLTERM0__6 BLTERM0__7
+  BLTERM0__8 BLTERM0__9 BLTERM0__10 BLTERM0__11 BLTERM0__12 BLTERM0__13
+  BLTERM0__14 BLTERM0__15 BLTERM1_0 BLTERM1_1 BLTERM1_2 BLTERM1_3 BLTERM1_4
+  BLTERM1_5 BLTERM1_6 BLTERM1_7 BLTERM1_8 BLTERM1_9 BLTERM1_10 BLTERM1_11
+  BLTERM1_12 BLTERM1_13 BLTERM1_14 BLTERM1_15 BLTERM1__0 BLTERM1__1
+  BLTERM1__2 BLTERM1__3 BLTERM1__4 BLTERM1__5 BLTERM1__6 BLTERM1__7
+  BLTERM1__8 BLTERM1__9 BLTERM1__10 BLTERM1__11 BLTERM1__12 BLTERM1__13
+  BLTERM1__14 BLTERM1__15 BLTERM2_0 BLTERM2_1 BLTERM2_2 BLTERM2_3 BLTERM2_4
+  BLTERM2_5 BLTERM2_6 BLTERM2_7 BLTERM2_8 BLTERM2_9 BLTERM2_10 BLTERM2_11
+  BLTERM2_12 BLTERM2_13 BLTERM2_14 BLTERM2_15 BLTERM2__0 BLTERM2__1
+  BLTERM2__2 BLTERM2__3 BLTERM2__4 BLTERM2__5 BLTERM2__6 BLTERM2__7
+  BLTERM2__8 BLTERM2__9 BLTERM2__10 BLTERM2__11 BLTERM2__12 BLTERM2__13
+  BLTERM2__14 BLTERM2__15 BLTERM3_0 BLTERM3_1 BLTERM3_2 BLTERM3_3 BLTERM3_4
+  BLTERM3_5 BLTERM3_6 BLTERM3_7 BLTERM3_8 BLTERM3_9 BLTERM3_10 BLTERM3_11
+  BLTERM3_12 BLTERM3_13 BLTERM3_14 BLTERM3_15 BLTERM3__0 BLTERM3__1
+  BLTERM3__2 BLTERM3__3 BLTERM3__4 BLTERM3__5 BLTERM3__6 BLTERM3__7
+  BLTERM3__8 BLTERM3__9 BLTERM3__10 BLTERM3__11 BLTERM3__12 BLTERM3__13
+  BLTERM3__14 BLTERM3__15 BLTERM4_0 BLTERM4_1 BLTERM4_2 BLTERM4_3 BLTERM4_4
+  BLTERM4_5 BLTERM4_6 BLTERM4_7 BLTERM4_8 BLTERM4_9 BLTERM4_10 BLTERM4_11
+  BLTERM4_12 BLTERM4_13 BLTERM4_14 BLTERM4_15 BLTERM4__0 BLTERM4__1
+  BLTERM4__2 BLTERM4__3 BLTERM4__4 BLTERM4__5 BLTERM4__6 BLTERM4__7
+  BLTERM4__8 BLTERM4__9 BLTERM4__10 BLTERM4__11 BLTERM4__12 BLTERM4__13
+  BLTERM4__14 BLTERM4__15 BLTERM5_0 BLTERM5_1 BLTERM5_2 BLTERM5_3 BLTERM5_4
+  BLTERM5_5 BLTERM5_6 BLTERM5_7 BLTERM5_8 BLTERM5_9 BLTERM5_10 BLTERM5_11
+  BLTERM5_12 BLTERM5_13 BLTERM5_14 BLTERM5_15 BLTERM5__0 BLTERM5__1
+  BLTERM5__2 BLTERM5__3 BLTERM5__4 BLTERM5__5 BLTERM5__6 BLTERM5__7
+  BLTERM5__8 BLTERM5__9 BLTERM5__10 BLTERM5__11 BLTERM5__12 BLTERM5__13
+  BLTERM5__14 BLTERM5__15 BLTERM6_0 BLTERM6_1 BLTERM6_2 BLTERM6_3 BLTERM6_4
+  BLTERM6_5 BLTERM6_6 BLTERM6_7 BLTERM6_8 BLTERM6_9 BLTERM6_10 BLTERM6_11
+  BLTERM6_12 BLTERM6_13 BLTERM6_14 BLTERM6_15 BLTERM6__0 BLTERM6__1
+  BLTERM6__2 BLTERM6__3 BLTERM6__4 BLTERM6__5 BLTERM6__6 BLTERM6__7
+  BLTERM6__8 BLTERM6__9 BLTERM6__10 BLTERM6__11 BLTERM6__12 BLTERM6__13
+  BLTERM6__14 BLTERM6__15 BLTERM7_0 BLTERM7_1 BLTERM7_2 BLTERM7_3 BLTERM7_4
+  BLTERM7_5 BLTERM7_6 BLTERM7_7 BLTERM7_8 BLTERM7_9 BLTERM7_10 BLTERM7_11
+  BLTERM7_12 BLTERM7_13 BLTERM7_14 BLTERM7_15 BLTERM7__0 BLTERM7__1
+  BLTERM7__2 BLTERM7__3 BLTERM7__4 BLTERM7__5 BLTERM7__6 BLTERM7__7
+  BLTERM7__8 BLTERM7__9 BLTERM7__10 BLTERM7__11 BLTERM7__12 BLTERM7__13
+  BLTERM7__14 BLTERM7__15 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6
+  BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 CE_WE
+  CREN_0 CREN_1 CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7 CREN_8 CREN_9
+  CREN_10 CREN_11 CREN_12 CREN_13 CREN_14 CREN_15 DNI_0 DNI_1 DNI_2 DNI_3
+  DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14
+  DNI_15 FIOGTP GDLA GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL__0 GDL__1 GDL__2 GDL__3
+  GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13
+  GDL__14 GDL__15 IOGTP IRET IRETN Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7
+  Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 TIEHIGH TIELOW YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** sram_AIO8RR16: 2756 flat devices **
XRIGHTIO0 BLTERM0_0 BLTERM0__0 BLTERM1_0 BLTERM1__0 BLTERM2_0 BLTERM2__0
+  BLTERM3_0 BLTERM3__0 BLTERM4_0 BLTERM4__0 BLTERM5_0 BLTERM5__0 BLTERM6_0
+  BLTERM6__0 BLTERM7_0 BLTERM7__0 BWEI_0 CE_WE CREN_0 TIEHIGH TIEHIGH TIEHIGH
+  DNI_0 FIOGTP GDL_0 GDLA TIEHIGH GDLA TIEHIGH GDLI_6 GDLI__8 GDL__0 IODL_12
+  IODL__10 IOGTP IRET IRETN Q__0 GDLA TIEHIGH GDLA WE_14 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_16 TIEHIGH TIEHIGH TIEHIGH VSS VDD sram_AIO8
XRIGHTIO1 BLTERM0_1 BLTERM0__1 BLTERM1_1 BLTERM1__1 BLTERM2_1 BLTERM2__1
+  BLTERM3_1 BLTERM3__1 BLTERM4_1 BLTERM4__1 BLTERM5_1 BLTERM5__1 BLTERM6_1
+  BLTERM6__1 BLTERM7_1 BLTERM7__1 BWEI_1 CE_WE CREN_1 TIEHIGH TIEHIGH TIEHIGH
+  DNI_1 FIOGTP GDL_1 GDLA TIEHIGH GDLA TIEHIGH GDLI_18 GDLI__20 GDL__1
+  IODL_24 IODL__22 IOGTP IRET IRETN Q__1 GDLA TIEHIGH GDLA WE_26 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_28 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO10 BLTERM0_10 BLTERM0__10 BLTERM1_10 BLTERM1__10 BLTERM2_10
+  BLTERM2__10 BLTERM3_10 BLTERM3__10 BLTERM4_10 BLTERM4__10 BLTERM5_10
+  BLTERM5__10 BLTERM6_10 BLTERM6__10 BLTERM7_10 BLTERM7__10 BWEI_10 CE_WE
+  CREN_10 TIEHIGH TIEHIGH TIEHIGH DNI_10 FIOGTP GDL_10 GDLA TIEHIGH GDLA
+  TIEHIGH GDLI_126 GDLI__128 GDL__10 IODL_132 IODL__130 IOGTP IRET IRETN
+  Q__10 GDLA TIEHIGH GDLA WE_134 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3
+  YSN_136 TIEHIGH TIEHIGH TIEHIGH VSS VDD sram_AIO8
XRIGHTIO11 BLTERM0_11 BLTERM0__11 BLTERM1_11 BLTERM1__11 BLTERM2_11
+  BLTERM2__11 BLTERM3_11 BLTERM3__11 BLTERM4_11 BLTERM4__11 BLTERM5_11
+  BLTERM5__11 BLTERM6_11 BLTERM6__11 BLTERM7_11 BLTERM7__11 BWEI_11 CE_WE
+  CREN_11 TIEHIGH TIEHIGH TIEHIGH DNI_11 FIOGTP GDL_11 GDLA TIEHIGH GDLA
+  TIEHIGH GDLI_138 GDLI__140 GDL__11 IODL_144 IODL__142 IOGTP IRET IRETN
+  Q__11 GDLA TIEHIGH GDLA WE_146 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3
+  YSN_148 TIEHIGH TIEHIGH TIEHIGH VSS VDD sram_AIO8
XRIGHTIO12 BLTERM0_12 BLTERM0__12 BLTERM1_12 BLTERM1__12 BLTERM2_12
+  BLTERM2__12 BLTERM3_12 BLTERM3__12 BLTERM4_12 BLTERM4__12 BLTERM5_12
+  BLTERM5__12 BLTERM6_12 BLTERM6__12 BLTERM7_12 BLTERM7__12 BWEI_12 CE_WE
+  CREN_12 TIEHIGH TIEHIGH TIEHIGH DNI_12 FIOGTP GDL_12 GDLA TIEHIGH GDLA
+  TIEHIGH GDLI_150 GDLI__152 GDL__12 IODL_156 IODL__154 IOGTP IRET IRETN
+  Q__12 GDLA TIEHIGH GDLA WE_158 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3
+  YSN_160 TIEHIGH TIEHIGH TIEHIGH VSS VDD sram_AIO8
XRIGHTIO13 BLTERM0_13 BLTERM0__13 BLTERM1_13 BLTERM1__13 BLTERM2_13
+  BLTERM2__13 BLTERM3_13 BLTERM3__13 BLTERM4_13 BLTERM4__13 BLTERM5_13
+  BLTERM5__13 BLTERM6_13 BLTERM6__13 BLTERM7_13 BLTERM7__13 BWEI_13 CE_WE
+  CREN_13 TIEHIGH TIEHIGH TIEHIGH DNI_13 FIOGTP GDL_13 GDLA TIEHIGH GDLA
+  TIEHIGH GDLI_162 GDLI__164 GDL__13 IODL_168 IODL__166 IOGTP IRET IRETN
+  Q__13 GDLA TIEHIGH GDLA WE_170 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3
+  YSN_172 TIEHIGH TIEHIGH TIEHIGH VSS VDD sram_AIO8
XRIGHTIO14 BLTERM0_14 BLTERM0__14 BLTERM1_14 BLTERM1__14 BLTERM2_14
+  BLTERM2__14 BLTERM3_14 BLTERM3__14 BLTERM4_14 BLTERM4__14 BLTERM5_14
+  BLTERM5__14 BLTERM6_14 BLTERM6__14 BLTERM7_14 BLTERM7__14 BWEI_14 CE_WE
+  CREN_14 TIEHIGH TIEHIGH TIEHIGH DNI_14 FIOGTP GDL_14 GDLA TIEHIGH GDLA
+  TIEHIGH GDLI_174 GDLI__176 GDL__14 IODL_180 IODL__178 IOGTP IRET IRETN
+  Q__14 GDLA TIEHIGH GDLA WE_182 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3
+  YSN_184 TIEHIGH TIEHIGH TIEHIGH VSS VDD sram_AIO8
XRIGHTIO2 BLTERM0_2 BLTERM0__2 BLTERM1_2 BLTERM1__2 BLTERM2_2 BLTERM2__2
+  BLTERM3_2 BLTERM3__2 BLTERM4_2 BLTERM4__2 BLTERM5_2 BLTERM5__2 BLTERM6_2
+  BLTERM6__2 BLTERM7_2 BLTERM7__2 BWEI_2 CE_WE CREN_2 TIEHIGH TIEHIGH TIEHIGH
+  DNI_2 FIOGTP GDL_2 GDLA TIEHIGH GDLA TIEHIGH GDLI_30 GDLI__32 GDL__2
+  IODL_36 IODL__34 IOGTP IRET IRETN Q__2 GDLA TIEHIGH GDLA WE_38 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_40 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO3 BLTERM0_3 BLTERM0__3 BLTERM1_3 BLTERM1__3 BLTERM2_3 BLTERM2__3
+  BLTERM3_3 BLTERM3__3 BLTERM4_3 BLTERM4__3 BLTERM5_3 BLTERM5__3 BLTERM6_3
+  BLTERM6__3 BLTERM7_3 BLTERM7__3 BWEI_3 CE_WE CREN_3 TIEHIGH TIEHIGH TIEHIGH
+  DNI_3 FIOGTP GDL_3 GDLA TIEHIGH GDLA TIEHIGH GDLI_42 GDLI__44 GDL__3
+  IODL_48 IODL__46 IOGTP IRET IRETN Q__3 GDLA TIEHIGH GDLA WE_50 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_52 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO4 BLTERM0_4 BLTERM0__4 BLTERM1_4 BLTERM1__4 BLTERM2_4 BLTERM2__4
+  BLTERM3_4 BLTERM3__4 BLTERM4_4 BLTERM4__4 BLTERM5_4 BLTERM5__4 BLTERM6_4
+  BLTERM6__4 BLTERM7_4 BLTERM7__4 BWEI_4 CE_WE CREN_4 TIEHIGH TIEHIGH TIEHIGH
+  DNI_4 FIOGTP GDL_4 GDLA TIEHIGH GDLA TIEHIGH GDLI_54 GDLI__56 GDL__4
+  IODL_60 IODL__58 IOGTP IRET IRETN Q__4 GDLA TIEHIGH GDLA WE_62 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_64 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO5 BLTERM0_5 BLTERM0__5 BLTERM1_5 BLTERM1__5 BLTERM2_5 BLTERM2__5
+  BLTERM3_5 BLTERM3__5 BLTERM4_5 BLTERM4__5 BLTERM5_5 BLTERM5__5 BLTERM6_5
+  BLTERM6__5 BLTERM7_5 BLTERM7__5 BWEI_5 CE_WE CREN_5 TIEHIGH TIEHIGH TIEHIGH
+  DNI_5 FIOGTP GDL_5 GDLA TIEHIGH GDLA TIEHIGH GDLI_66 GDLI__68 GDL__5
+  IODL_72 IODL__70 IOGTP IRET IRETN Q__5 GDLA TIEHIGH GDLA WE_74 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_76 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO6 BLTERM0_6 BLTERM0__6 BLTERM1_6 BLTERM1__6 BLTERM2_6 BLTERM2__6
+  BLTERM3_6 BLTERM3__6 BLTERM4_6 BLTERM4__6 BLTERM5_6 BLTERM5__6 BLTERM6_6
+  BLTERM6__6 BLTERM7_6 BLTERM7__6 BWEI_6 CE_WE CREN_6 TIEHIGH TIEHIGH TIEHIGH
+  DNI_6 FIOGTP GDL_6 GDLA TIEHIGH GDLA TIEHIGH GDLI_78 GDLI__80 GDL__6
+  IODL_84 IODL__82 IOGTP IRET IRETN Q__6 GDLA TIEHIGH GDLA WE_86 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_88 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO7 BLTERM0_7 BLTERM0__7 BLTERM1_7 BLTERM1__7 BLTERM2_7 BLTERM2__7
+  BLTERM3_7 BLTERM3__7 BLTERM4_7 BLTERM4__7 BLTERM5_7 BLTERM5__7 BLTERM6_7
+  BLTERM6__7 BLTERM7_7 BLTERM7__7 BWEI_7 CE_WE CREN_7 TIEHIGH TIEHIGH TIEHIGH
+  DNI_7 FIOGTP GDL_7 GDLA TIEHIGH GDLA TIEHIGH GDLI_90 GDLI__92 GDL__7
+  IODL_96 IODL__94 IOGTP IRET IRETN Q__7 GDLA TIEHIGH GDLA WE_98 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_100 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO8 BLTERM0_8 BLTERM0__8 BLTERM1_8 BLTERM1__8 BLTERM2_8 BLTERM2__8
+  BLTERM3_8 BLTERM3__8 BLTERM4_8 BLTERM4__8 BLTERM5_8 BLTERM5__8 BLTERM6_8
+  BLTERM6__8 BLTERM7_8 BLTERM7__8 BWEI_8 CE_WE CREN_8 TIEHIGH TIEHIGH TIEHIGH
+  DNI_8 FIOGTP GDL_8 GDLA TIEHIGH GDLA TIEHIGH GDLI_102 GDLI__104 GDL__8
+  IODL_108 IODL__106 IOGTP IRET IRETN Q__8 GDLA TIEHIGH GDLA WE_110 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_112 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIO9 BLTERM0_9 BLTERM0__9 BLTERM1_9 BLTERM1__9 BLTERM2_9 BLTERM2__9
+  BLTERM3_9 BLTERM3__9 BLTERM4_9 BLTERM4__9 BLTERM5_9 BLTERM5__9 BLTERM6_9
+  BLTERM6__9 BLTERM7_9 BLTERM7__9 BWEI_9 CE_WE CREN_9 TIEHIGH TIEHIGH TIEHIGH
+  DNI_9 FIOGTP GDL_9 GDLA TIEHIGH GDLA TIEHIGH GDLI_114 GDLI__116 GDL__9
+  IODL_120 IODL__118 IOGTP IRET IRETN Q__9 GDLA TIEHIGH GDLA WE_122 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_124 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XRIGHTIOEDGE16 CE_WE TIEHIGH FIOGTP GDLA TIEHIGH IOGTP IRETN IRET VSS TIEHIGH
+  TIELOW GDLA GDLA YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH VSS VDD sram_AIO8EDGE
XRIGHTIOEXT15 BLTERM0_15 BLTERM0__15 BLTERM1_15 BLTERM1__15 BLTERM2_15
+  BLTERM2__15 BLTERM3_15 BLTERM3__15 BLTERM4_15 BLTERM4__15 BLTERM5_15
+  BLTERM5__15 BLTERM6_15 BLTERM6__15 BLTERM7_15 BLTERM7__15 BWEI_15 CE_WE
+  CREN_15 TIEHIGH TIEHIGH TIEHIGH DNI_15 FIOGTP GDL_15 GDLA TIEHIGH GDLA
+  TIEHIGH GDLI GDLI_ GDL__15 IODL IODL_ IOGTP IRET IRETN Q__15 GDLA TIEHIGH
+  GDLA WE GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN TIEHIGH TIEHIGH
+  TIEHIGH VSS VDD sram_AIO8
.ENDS sram_AIO8RR16
****
.SUBCKT sram_ACTRL AGTP AGTPN AX6N AY3 AY4 BS0N BS1N CEI CE_WE CLK CREN_TERM
+  EMA0 EMA1 EMA2 FIOGTPL FIOGTPR GDLA_TERM GDLA__TERM GTP GTPDE GTPDEI GTPDET
+  GTPDS GTPDSF GTPDST IOGTPL IOGTPR IRET IRETN LGWEN MBL MGDLE MGDLET MGDLS
+  MGDLST MGTPS MWLLATE PG_TERM PRDT PWBT RDT RETN RRENDD STOV TIEHIGH TIELOW
+  TL0_TERM WBTDD WEI WE_TERM YP1_0 YP1_1 YP1_2 YP1_3 YSNA_TERM VSS VDD
** sram_ACTRL: 383 flat devices **
D381 VSS EMA1 NDIO 1.024e-07U 1.28U $name=/D5
D382 VSS EMA2 NDIO 1.024e-07U 1.28U $name=/D4
M0 HNET185 GTP VSS VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N31
M1 DELAYEDMBL NET819 HNET185 VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N30
M10 HNET190 NET665 VSS VSS NCH W=1.75U L=0.06U M=1 $name=/I14/N11
M100 VDD GTPB GTP VDD PCH W=6.3U L=0.06U M=1 $name=/tgpdrvp2/P00
M101 VDD GTP NET552 VDD PCH W=0.3U L=0.12U M=1 $name=/tdlyp3a/P00
M102 VDD NET552 NET555 VDD PCH W=0.36U L=0.06U M=1 $name=/tdlyp2/P00
M103 NET0509 GTP MSI VDD PCH W=0.45U L=0.06U M=1 $name=/tdlyp1/P00
M104 NET789 RGWEN NET575 VDD PCH W=0.3U L=0.06U M=1 $name=/P8/P00
M105 VDD NET578 NET518 VDD PCH W=0.15U L=0.06U M=1 $name=/P5/P00
M106 VDD NET575 GTPDED VDD PCH W=0.15U L=0.06U M=1 $name=/P3/P00
M107 NET0418 RGWE NET575 VDD PCH W=0.3U L=0.06U M=1 $name=/P23/P00
M108 VDD GTP NET0509 VDD PCH W=0.45U L=0.12U M=1 $name=/P2/P00
M109 VDD TIEHIGH TIEHIGH VDD PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M11 AGTP GTPB HNET190 VSS NCH W=1.75U L=0.06U M=1 $name=/I14/N10
M110 VDD NET566 TIEHIGH VDD PCH W=0.9U L=0.06U M=1 $name=/P0/P00
M111 GTP IRET VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N0/N00
M112 NET555 NET552 VSS VSS NCH_HVT W=0.3U L=0.12U M=1 $name=/tdlyn2a/N00
M113 EMAPRE EMA00 NET407 VSS NCH_HVT W=0.89U L=0.06U M=1 $name=/dlypassn/N00
M114 EMAPRE EMA11 NET514 VSS NCH_HVT W=0.89U L=0.06U M=1 $name=/N28/N00
M115 EMAPRE EMA10 NET700 VSS NCH_HVT W=0.89U L=0.06U M=1 $name=/N27/N00
M116 NET518 NET578 NET584 VSS NCH_HVT W=0.45U L=0.12U M=1 $name=/N25/N00
M117 EMAPRE EMA01 NET703 VSS NCH_HVT W=0.89U L=0.06U M=1 $name=/N24/N00
M118 GTPDS IRET VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M119 NET0418 GTPDEI VSS VSS NCH W=0.22U L=0.06U M=1 $name=/N3/N00
M12 HNET188 NET665 VSS VSS NCH W=1.75U L=0.06U M=1 $name=/I14/N01
M120 WELOUT AGTPN WEI VSS NCH W=0.36U L=0.06U M=1 $name=/tpgwen4/N00
M121 RGWEB AGTP NET810 VSS NCH W=0.15U L=0.06U M=1 $name=/tpgwen3/N00
M122 NET610 AGTPN RGWEB VSS NCH W=0.15U L=0.06U M=1 $name=/tpgwen2/N00
M123 NET536 AGTP WELOUT VSS NCH W=0.15U L=0.06U M=1 $name=/tpgwen1/N00
M124 NET575 RGWEN NET0418 VSS NCH W=0.15U L=0.06U M=1 $name=/tnpggtpde/N00
M125 GTP SETGTP NET547 VSS NCH W=3U L=0.06U M=1 $name=/tgtpdrvn/N00
M126 NET552 GTP VSS VSS NCH W=0.75U L=0.06U M=1 $name=/tdlyn3/N00
M127 VSS NET552 VSS VSS NCH W=0.3U L=0.12U M=1 $name=/tdlyn2b/N00
M128 MSI GTP VSS VSS NCH W=1.4U L=0.06U M=1 $name=/tdlyn1/N00
M129 SETGTP A CLKB VSS NCH W=6.78U L=0.06U M=1 $name=/tclkbn/N00
M13 AGTP GTPB HNET188 VSS NCH W=1.75U L=0.06U M=1 $name=/I14/N00
M130 NET566 NET566 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N9/N00
M131 NET592 GTPB VSS VSS NCH W=3U L=0.06U M=1 $name=/N7/N00
M132 NET547 GTPB VSS VSS NCH W=3U L=0.06U M=1 $name=/N6/N00
M133 NET575 RGWE NET789 VSS NCH W=0.15U L=0.06U M=1 $name=/N31/N00
M134 NET578 TIELOW VSS VSS NCH W=0.22U L=0.06U M=1 $name=/N30/N00
M135 NET584 NET578 VSS VSS NCH W=0.45U L=0.12U M=1 $name=/N26/N00
M136 GTPDED NET575 VSS VSS NCH W=0.45U L=0.06U M=1 $name=/N22/N00
M137 NET595 GTPB VSS VSS NCH W=3U L=0.06U M=1 $name=/N2/N00
M138 GTP SETGTP NET592 VSS NCH W=3U L=0.06U M=1 $name=/N18/N00
M139 GTP SETGTP NET595 VSS NCH W=3U L=0.06U M=1 $name=/N16/N00
M14 VDD NET665 AGTP VDD PCH W=3.5U L=0.06U M=1 $name=/I14/P10
M140 GTP SETGTP NET605 VSS NCH W=3U L=0.06U M=1 $name=/N14/N00
M141 NET566 TIEHIGH VSS VSS NCH W=0.9U L=0.06U M=1 $name=/N10/N00
M142 NET605 GTPB VSS VSS NCH W=3U L=0.06U M=1 $name=/N1/N00
M143 NET610 RGWE VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv2/N00
M144 VDD RGWE NET610 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv2/P00
M145 NET536 NET810 VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv1/N00
M146 VDD NET810 NET536 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv1/P00
M147 STOVB STOVI VSS VSS NCH_HVT W=0.23U L=0.06U M=1 $name=/stovsel/N00
M148 VDD STOVI STOVB VDD PCH_HVT W=0.32U L=0.06U M=1 $name=/stovsel/P00
M149 EMA00 EMA00B VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/selinv/N00
M15 VDD GTPB AGTP VDD PCH W=3.5U L=0.06U M=1 $name=/I14/P00
M150 VDD EMA00B EMA00 VDD PCH_HVT W=0.17U L=0.06U M=1 $name=/selinv/P00
M151 NET713 EMA1N VSS VSS NCH_HVT W=0.22U L=0.06U M=1 $name=/sel1/N00
M152 VDD EMA1N NET713 VDD PCH_HVT W=0.28U L=0.06U M=1 $name=/sel1/P00
M153 NET715 EMA0N VSS VSS NCH_HVT W=0.22U L=0.06U M=1 $name=/sel0/N00
M154 VDD EMA0N NET715 VDD PCH_HVT W=0.28U L=0.06U M=1 $name=/sel0/P00
M155 MBLSELN MBLSEL VSS VSS NCH_HVT W=0.2U L=0.06U M=1 $name=/mblsel0/N00
M156 VDD MBLSEL MBLSELN VDD PCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel0/P00
M157 LONGEMA NET625 VSS VSS NCH_HVT W=0.25U L=0.06U M=1 $name=/longd4/N00
M158 VDD NET625 LONGEMA VDD PCH_HVT W=0.35U L=0.06U M=1 $name=/longd4/P00
M159 NET694 NET627 VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/longd1/N00
M16 HNET195 DELAYEDGTP VSS VSS NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N11
M160 VDD NET627 NET694 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/longd1/P00
M161 NET631 MBLN VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/gdlyinv2/N00
M162 VDD MBLN NET631 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/gdlyinv2/P00
M163 NET630 NET631 VSS VSS NCH_HVT W=0.18U L=0.06U M=1 $name=/gdlyinv1/N00
M164 VDD NET631 NET630 VDD PCH_HVT W=0.33U L=0.06U M=1 $name=/gdlyinv1/P00
M165 NET514 NET699 VSS VSS NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv3/N00
M166 VDD NET699 NET514 VDD PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv3/P00
M167 NET700 NET635 VSS VSS NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv2/N00
M168 VDD NET635 NET700 VDD PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv2/P00
M169 NET703 NET405 VSS VSS NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv1/N00
M17 RESETGTP DELAYEDMBL HNET195 VSS NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N10
M170 VDD NET405 NET703 VDD PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv1/P00
M171 NET407 NET639 VSS VSS NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv0/N00
M172 VDD NET639 NET407 VDD PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv0/P00
M173 NET640 PRDT VSS VSS NCH_HVT W=0.3U L=0.06U M=1 $name=/I99/N00
M174 VDD PRDT NET640 VDD PCH_HVT W=0.41U L=0.06U M=1 $name=/I99/P00
M175 EMA10 EMA10B VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/I93/N00
M176 VDD EMA10B EMA10 VDD PCH_HVT W=0.17U L=0.06U M=1 $name=/I93/P00
M177 EMA11 EMA11B VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/I92/N00
M178 VDD EMA11B EMA11 VDD PCH_HVT W=0.17U L=0.06U M=1 $name=/I92/P00
M179 EMA01 EMA01B VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/I91/N00
M18 HNET193 DELAYEDGTP VSS VSS NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N01
M180 VDD EMA01B EMA01 VDD PCH_HVT W=0.17U L=0.06U M=1 $name=/I91/P00
M181 EMA0N EMA0 VSS VSS NCH_HVT W=0.44U L=0.06U M=1 $name=/I90/N00
M182 VDD EMA0 EMA0N VDD PCH_HVT W=0.56U L=0.06U M=1 $name=/I90/P00
M183 NET688 STOV VSS VSS NCH_HVT W=0.3U L=0.06U M=1 $name=/I89/N00
M184 VDD STOV NET688 VDD PCH_HVT W=0.42U L=0.06U M=1 $name=/I89/P00
M185 EMA2N EMA2 VSS VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/I88/N00
M186 VDD EMA2 EMA2N VDD PCH_HVT W=0.58U L=0.06U M=1 $name=/I88/P00
M187 EMA1N EMA1 VSS VSS NCH_HVT W=0.44U L=0.06U M=1 $name=/I87/N00
M188 VDD EMA1 EMA1N VDD PCH_HVT W=0.56U L=0.06U M=1 $name=/I87/P00
M189 HNET492 DELAYEDGTP VSS VSS NCH W=1.86U L=0.06U M=1 $name=/tsend/N01
M19 RESETGTP DELAYEDMBL HNET193 VSS NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N00
M190 NET729 CLKB HNET492 VSS NCH W=1.86U L=0.06U M=1 $name=/tsend/N00
M191 VDD DELAYEDGTP NET729 VDD PCH W=1.26U L=0.06U M=1 $name=/tsend/P10
M192 VDD CLKB NET729 VDD PCH W=1.26U L=0.06U M=1 $name=/tsend/P00
M193 HNET496 RESETGTP VSS VSS NCH W=4.62U L=0.06U M=1 $name=/tgtprsnd/N01
M194 GTPB GTP HNET496 VSS NCH W=4.62U L=0.06U M=1 $name=/tgtprsnd/N00
M195 VDD RESETGTP GTPB VDD PCH W=3.54U L=0.06U M=1 $name=/tgtprsnd/P10
M196 VDD GTP GTPB VDD PCH W=3.54U L=0.06U M=1 $name=/tgtprsnd/P00
M197 HNET500 RGWEN VSS VSS NCH W=0.75U L=0.06U M=1 $name=/tgtpdnd2/N01
M198 NET663 MGDLE HNET500 VSS NCH W=0.75U L=0.06U M=1 $name=/tgtpdnd2/N00
M199 VDD RGWEN NET663 VDD PCH W=0.51U L=0.06U M=1 $name=/tgtpdnd2/P10
M2 HNET180 GTP VSS VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N21
M20 VDD DELAYEDGTP RESETGTP VDD PCH W=1.58U L=0.06U M=1 $name=/trstgtpw/P10
M200 VDD MGDLE NET663 VDD PCH W=0.51U L=0.06U M=1 $name=/tgtpdnd2/P00
M201 HNET504 NET663 VSS VSS NCH W=1.57U L=0.06U M=1 $name=/tgtpddrv3/N01
M202 NET666 NET665 HNET504 VSS NCH W=1.57U L=0.06U M=1 $name=/tgtpddrv3/N00
M203 VDD NET663 NET666 VDD PCH W=1.07U L=0.06U M=1 $name=/tgtpddrv3/P10
M204 VDD NET665 NET666 VDD PCH W=1.07U L=0.06U M=1 $name=/tgtpddrv3/P00
M205 HNET508 AB VSS VSS NCH W=1.55U L=0.06U M=1 $name=/tgsetnd/N01
M206 NET798 GTPNDDW HNET508 VSS NCH W=1.55U L=0.06U M=1 $name=/tgsetnd/N00
M207 VDD AB NET798 VDD PCH W=1.05U L=0.06U M=1 $name=/tgsetnd/P10
M208 VDD GTPNDDW NET798 VDD PCH W=1.05U L=0.06U M=1 $name=/tgsetnd/P00
M209 HNET512 CLKB VSS VSS NCH W=0.3U L=0.06U M=1 $name=/tclkce/N01
M21 VDD DELAYEDMBL RESETGTP VDD PCH W=1.58U L=0.06U M=1 $name=/trstgtpw/P00
M210 CLKCE CEI HNET512 VSS NCH W=0.3U L=0.06U M=1 $name=/tclkce/N00
M211 VDD CLKB CLKCE VDD PCH W=0.33U L=0.06U M=1 $name=/tclkce/P10
M212 VDD CEI CLKCE VDD PCH W=0.33U L=0.06U M=1 $name=/tclkce/P00
M213 HNET516 CLK VSS VSS NCH W=0.18U L=0.06U M=1 $name=/tcknd/N01
M214 NET675 RETDD HNET516 VSS NCH W=0.18U L=0.06U M=1 $name=/tcknd/N00
M215 VDD CLK NET675 VDD PCH W=0.33U L=0.06U M=1 $name=/tcknd/P10
M216 VDD RETDD NET675 VDD PCH W=0.33U L=0.06U M=1 $name=/tcknd/P00
M217 HNET520 NET688 VSS VSS NCH_HVT W=1.26U L=0.06U M=1 $name=/tstovnd/N01
M218 STOVI NET640 HNET520 VSS NCH_HVT W=1.26U L=0.06U M=1 $name=/tstovnd/N00
M219 VDD NET688 STOVI VDD PCH_HVT W=0.86U L=0.06U M=1 $name=/tstovnd/P10
M22 HNET200 AY4 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N11
M220 VDD NET640 STOVI VDD PCH_HVT W=0.86U L=0.06U M=1 $name=/tstovnd/P00
M221 HNET524 EMA0N VSS VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/selnand/N01
M222 EMA00B EMA1N HNET524 VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/selnand/N00
M223 VDD EMA0N EMA00B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/selnand/P10
M224 VDD EMA1N EMA00B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/selnand/P00
M225 HNET528 NET694 VSS VSS NCH_HVT W=0.17U L=0.06U M=1 $name=/longd3/N01
M226 NET625 DELAYEDGTP HNET528 VSS NCH_HVT W=0.17U L=0.06U M=1 $name=/longd3/N00
M227 VDD NET694 NET625 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/longd3/P10
M228 VDD DELAYEDGTP NET625 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/longd3/P00
M229 HNET532 NET630 VSS VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/N01
M23 NET660 AY3 HNET200 VSS NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N10
M230 NET627 DELAYEDGTP HNET532 VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/N00
M231 VDD NET630 NET627 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/P10
M232 VDD DELAYEDGTP NET627 VDD PCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/P00
M233 HNET536 NET700 VSS VSS NCH_HVT W=0.81U L=0.06U M=1 $name=/dlynand3/N01
M234 NET699 DELAYEDGTP HNET536 VSS NCH_HVT W=0.81U L=0.06U M=1 $name=/dlynand3/N00
M235 VDD NET700 NET699 VDD PCH_HVT W=0.56U L=0.06U M=1 $name=/dlynand3/P10
M236 VDD DELAYEDGTP NET699 VDD PCH_HVT W=0.56U L=0.06U M=1 $name=/dlynand3/P00
M237 HNET540 NET703 VSS VSS NCH_HVT W=1.04U L=0.06U M=1 $name=/dlynand2/N01
M238 NET635 MBLN HNET540 VSS NCH_HVT W=1.04U L=0.06U M=1 $name=/dlynand2/N00
M239 VDD NET703 NET635 VDD PCH_HVT W=0.72U L=0.06U M=1 $name=/dlynand2/P10
M24 HNET198 AY4 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N01
M240 VDD MBLN NET635 VDD PCH_HVT W=0.72U L=0.06U M=1 $name=/dlynand2/P00
M241 HNET544 LONGEMA VSS VSS NCH_HVT W=1.07U L=0.06U M=1 $name=/dlynand0/N01
M242 NET639 DELAYEDGTP HNET544 VSS NCH_HVT W=1.07U L=0.06U M=1 $name=/dlynand0/N00
M243 VDD LONGEMA NET639 VDD PCH_HVT W=0.73U L=0.06U M=1 $name=/dlynand0/P10
M244 VDD DELAYEDGTP NET639 VDD PCH_HVT W=0.73U L=0.06U M=1 $name=/dlynand0/P00
M245 HNET548 MBLN VSS VSS NCH_HVT W=1.86U L=0.06U M=1 $name=/dlydrv0/N01
M246 NET721 EMAPRE HNET548 VSS NCH_HVT W=1.86U L=0.06U M=1 $name=/dlydrv0/N00
M247 VDD MBLN NET721 VDD PCH_HVT W=1.26U L=0.06U M=1 $name=/dlydrv0/P10
M248 VDD EMAPRE NET721 VDD PCH_HVT W=1.26U L=0.06U M=1 $name=/dlydrv0/P00
M249 HNET552 EMA0N VSS VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/I137/N01
M25 NET660 AY3 HNET198 VSS NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N00
M250 EMA10B NET713 HNET552 VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/I137/N00
M251 VDD EMA0N EMA10B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/I137/P10
M252 VDD NET713 EMA10B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/I137/P00
M253 HNET556 NET715 VSS VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/I136/N01
M254 EMA11B NET713 HNET556 VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/I136/N00
M255 VDD NET715 EMA11B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/I136/P10
M256 VDD NET713 EMA11B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/I136/P00
M257 HNET560 NET715 VSS VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/I12/N01
M258 EMA01B EMA1N HNET560 VSS NCH_HVT W=0.43U L=0.06U M=1 $name=/I12/N00
M259 VDD NET715 EMA01B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/I12/P10
M26 VDD AY4 NET660 VDD PCH W=2.5U L=0.06U M=1 $name=/tioypnd/P10
M260 VDD EMA1N EMA01B VDD PCH_HVT W=0.29U L=0.06U M=1 $name=/I12/P00
M261 HNET567 NET721 VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I25/NI00
M262 STOVREMA STOVB HNET567 VSS NCH W=0.3U L=0.06U M=1 $name=/I25/NE00
M263 HNET562 STOVI STOVREMA VDD PCH W=0.6U L=0.06U M=1 $name=/I25/PE00
M264 VDD NET721 HNET562 VDD PCH W=0.6U L=0.06U M=1 $name=/I25/PI00
M265 HNET573 STOVREMA VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I28/NI00
M266 NET607 MBLSELN HNET573 VSS NCH W=0.3U L=0.06U M=1 $name=/I28/NE00
M267 HNET568 MBLSEL NET607 VDD PCH W=0.6U L=0.06U M=1 $name=/I28/PE00
M268 VDD STOVREMA HNET568 VDD PCH W=0.6U L=0.06U M=1 $name=/I28/PI00
M269 HNET579 NET729 VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I26/NI00
M27 VDD AY3 NET660 VDD PCH W=2.5U L=0.06U M=1 $name=/tioypnd/P00
M270 STOVREMA STOVI HNET579 VSS NCH W=0.3U L=0.06U M=1 $name=/I26/NE00
M271 HNET574 STOVB STOVREMA VDD PCH W=0.6U L=0.06U M=1 $name=/I26/PE00
M272 VDD NET729 HNET574 VDD PCH W=0.6U L=0.06U M=1 $name=/I26/PI00
M273 HNET585 NET734 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tiretntri/NI00
M274 NET390 NET734 HNET585 VSS NCH W=0.15U L=0.06U M=1 $name=/tiretntri/NE00
M275 HNET580 NET734 NET390 VDD PCH W=0.15U L=0.06U M=1 $name=/tiretntri/PE00
M276 VDD NET734 HNET580 VDD PCH W=0.15U L=0.06U M=1 $name=/tiretntri/PI00
M277 HNET591 MBLN VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I30/NI00
M278 NET607 MBLSEL HNET591 VSS NCH W=0.3U L=0.06U M=1 $name=/I30/NE00
M279 HNET586 MBLSELN NET607 VDD PCH W=0.6U L=0.06U M=1 $name=/I30/PE00
M28 HNET205 NET679 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I37/N11
M280 VDD MBLN HNET586 VDD PCH W=0.6U L=0.06U M=1 $name=/I30/PI00
M281 HNET597 IRET VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I10/NI00
M282 NET734 IRET HNET597 VSS NCH W=0.15U L=0.06U M=1 $name=/I10/NE00
M283 HNET592 IRET NET734 VDD PCH W=0.15U L=0.06U M=1 $name=/I10/PE00
M284 VDD IRET HNET592 VDD PCH W=0.15U L=0.06U M=1 $name=/I10/PI00
M285 NET665 MGDLE VSS VSS NCH W=0.36U L=0.06U M=1 $name=/taptdrvb/N00
M286 VDD MGDLE NET665 VDD PCH W=0.75U L=0.06U M=1 $name=/taptdrvb/P00
M287 MGTPS NET747 VSS VSS NCH W=3U L=0.06U M=1 $name=/I7/N00
M288 VDD NET747 MGTPS VDD PCH W=6U L=0.06U M=1 $name=/I7/P00
M289 NET747 GTP VSS VSS NCH W=1.1U L=0.06U M=1 $name=/I8/N00
M29 NET678 NET677 HNET205 VSS NCH W=1.25U L=0.06U M=1 $name=/I37/N10
M290 VDD GTP NET747 VDD PCH W=2U L=0.06U M=1 $name=/I8/P00
M291 AGTPN AGTP VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I168/N00
M292 VDD AGTP AGTPN VDD PCH W=3.52U L=0.06U M=1 $name=/I168/P00
M293 GTPDSF NET789 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I24/N00
M294 VDD NET789 GTPDSF VDD PCH W=0.3U L=0.06U M=1 $name=/I24/P00
M295 NET606 NET607 VSS VSS NCH W=0.35U L=0.06U M=1 $name=/I31/N00
M296 VDD NET607 NET606 VDD PCH W=0.7U L=0.06U M=1 $name=/I31/P00
M297 WBTDD NET755 VSS VSS NCH W=0.7U L=0.06U M=1 $name=/twbtdrv/N00
M298 VDD NET755 WBTDD VDD PCH W=1.5U L=0.06U M=1 $name=/twbtdrv/P00
M299 NET755 PWBT VSS VSS NCH W=0.25U L=0.06U M=1 $name=/twbtb/N00
M3 DELAYEDMBL NET819 HNET180 VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N20
M30 HNET203 NET679 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I37/N01
M300 VDD PWBT NET755 VDD PCH W=0.5U L=0.06U M=1 $name=/twbtb/P00
M301 IRET RETDD VSS VSS NCH W=3U L=0.06U M=1 $name=/tretdrv/N00
M302 VDD RETDD IRET VDD PCH W=6U L=0.06U M=1 $name=/tretdrv/P00
M303 RETDD NET389 VSS VSS NCH W=0.5U L=0.06U M=1 $name=/tretdd/N00
M304 VDD NET389 RETDD VDD PCH W=1U L=0.06U M=1 $name=/tretdd/P00
M305 RDT NET763 VSS VSS NCH W=1.5U L=0.06U M=1 $name=/trdtdrv/N00
M306 VDD NET763 RDT VDD PCH W=3U L=0.06U M=1 $name=/trdtdrv/P00
M307 NET763 PRDT VSS VSS NCH W=0.5U L=0.06U M=1 $name=/trdtb/N00
M308 VDD PRDT NET763 VDD PCH W=1U L=0.06U M=1 $name=/trdtb/P00
M309 MBLN MBL VSS VSS NCH W=0.8U L=0.06U M=1 $name=/tmblndrv/N00
M31 NET678 NET677 HNET203 VSS NCH W=1.25U L=0.06U M=1 $name=/I37/N00
M310 VDD MBL MBLN VDD PCH W=1U L=0.06U M=1 $name=/tmblndrv/P00
M311 DELAYEDGTP NET767 VSS VSS NCH W=1.11U L=0.06U M=1 $name=/tlond/N00
M312 VDD NET767 DELAYEDGTP VDD PCH W=1.48U L=0.06U M=1 $name=/tlond/P00
M313 NET810 WELOUT VSS VSS NCH W=0.71U L=0.06U M=1 $name=/tlgweninv2/N00
M314 VDD WELOUT NET810 VDD PCH W=0.98U L=0.06U M=1 $name=/tlgweninv2/P00
M315 RGWE RGWEB VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tlgweninv1/N00
M316 VDD RGWEB RGWE VDD PCH W=0.2U L=0.06U M=1 $name=/tlgweninv1/P00
M317 IRETN NET774 VSS VSS NCH W=0.79U L=0.06U M=1 $name=/tiretndrv/N00
M318 VDD NET774 IRETN VDD PCH W=1.08U L=0.06U M=1 $name=/tiretndrv/P00
M319 NET774 NET776 VSS VSS NCH W=0.27U L=0.06U M=1 $name=/tiretnd/N00
M32 VDD NET679 NET678 VDD PCH W=2.5U L=0.06U M=1 $name=/I37/P10
M320 VDD NET776 NET774 VDD PCH W=0.36U L=0.06U M=1 $name=/tiretnd/P00
M321 YP1_3 NET660 VSS VSS NCH W=5U L=0.06U M=1 $name=/tioypdrv0/N00
M322 VDD NET660 YP1_3 VDD PCH W=10U L=0.06U M=1 $name=/tioypdrv0/P00
M323 NET677 AY3 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/tinvaydd/N00
M324 VDD AY3 NET677 VDD PCH W=1.6U L=0.06U M=1 $name=/tinvaydd/P00
M325 IOGTPR IOGTPN VSS VSS NCH W=5U L=0.06U M=1 $name=/tgtprstdrv/N00
M326 VDD IOGTPN IOGTPR VDD PCH W=10U L=0.06U M=1 $name=/tgtprstdrv/P00
M327 GTPNDDW NET787 VSS VSS NCH W=0.37U L=0.06U M=1 $name=/tgtpnddwdrv/N00
M328 VDD NET787 GTPNDDW VDD PCH W=0.5U L=0.06U M=1 $name=/tgtpnddwdrv/P00
M329 RGWEN RGWE VSS VSS NCH W=0.16U L=0.06U M=1 $name=/tgtpdinv/N00
M33 VDD NET677 NET678 VDD PCH W=2.5U L=0.06U M=1 $name=/I37/P00
M330 VDD RGWE RGWEN VDD PCH W=0.22U L=0.06U M=1 $name=/tgtpdinv/P00
M331 NET787 GTPB VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tgtpddwdrv/N00
M332 VDD GTPB NET787 VDD PCH W=0.17U L=0.06U M=1 $name=/tgtpddwdrv/P00
M333 NET789 NET666 VSS VSS NCH W=1.75U L=0.06U M=1 $name=/tgtpddrv2/N00
M334 VDD NET666 NET789 VDD PCH W=2.5U L=0.06U M=1 $name=/tgtpddrv2/P00
M335 GTPDS NET789 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/tgtpddrv1/N00
M336 VDD NET789 GTPDS VDD PCH W=7U L=0.06U M=1 $name=/tgtpddrv1/P00
M337 A NET798 VSS VSS NCH W=2.28U L=0.06U M=1 $name=/tgset3/N00
M338 VDD NET798 A VDD PCH W=3U L=0.06U M=1 $name=/tgset3/P00
M339 NET795 CLKCEGTPIN VSS VSS NCH W=0.77U L=0.06U M=1 $name=/tgset2/N00
M34 HNET210 NET679 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I36/N11
M340 VDD CLKCEGTPIN NET795 VDD PCH W=1.05U L=0.06U M=1 $name=/tgset2/P00
M341 CLKCEGTPIN NET798 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tgset/N00
M342 VDD NET798 CLKCEGTPIN VDD PCH W=0.15U L=0.06U M=1 $name=/tgset/P00
M343 FIOGTPR DELAYEDMBL VSS VSS NCH W=5U L=0.06U M=1 $name=/tfiogtpdrv/N00
M344 VDD DELAYEDMBL FIOGTPR VDD PCH W=10U L=0.06U M=1 $name=/tfiogtpdrv/P00
M345 CKI NET675 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tckidrv/N00
M346 VDD NET675 CKI VDD PCH W=0.15U L=0.06U M=1 $name=/tckidrv/P00
M347 IWE WEI VSS VSS NCH W=1.5U L=0.06U M=1 $name=/tcewedrvb/N00
M348 VDD WEI IWE VDD PCH W=3U L=0.06U M=1 $name=/tcewedrvb/P00
M349 CE_WE IWE VSS VSS NCH W=5U L=0.06U M=1 $name=/tcewedrv/N00
M35 NET681 AY3 HNET210 VSS NCH W=1.25U L=0.06U M=1 $name=/I36/N10
M350 VDD IWE CE_WE VDD PCH W=10U L=0.06U M=1 $name=/tcewedrv/P00
M351 NET679 AY4 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/tay1/N00
M352 VDD AY4 NET679 VDD PCH W=1.6U L=0.06U M=1 $name=/tay1/P00
M353 LGWE NET810 VSS VSS NCH W=0.86U L=0.06U M=1 $name=/gwepdrv/N00
M354 VDD NET810 LGWE VDD PCH W=1.17U L=0.06U M=1 $name=/gwepdrv/P00
M355 LGWEN LGWE VSS VSS NCH W=2U L=0.06U M=1 $name=/gwedrv/N00
M356 VDD LGWE LGWEN VDD PCH W=4U L=0.06U M=1 $name=/gwedrv/P00
M357 MGDLS MSI VSS VSS NCH W=1U L=0.06U M=1 $name=/gmgdldrv1/N00
M358 VDD MSI MGDLS VDD PCH W=5U L=0.06U M=1 $name=/gmgdldrv1/P00
M359 NET818 PIOGTPN VSS VSS NCH W=0.75U L=0.06U M=1 $name=/giogtpinv2/N00
M36 HNET208 NET679 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I36/N01
M360 VDD PIOGTPN NET818 VDD PCH W=1.5U L=0.06U M=1 $name=/giogtpinv2/P00
M361 IOGTPN NET818 VSS VSS NCH W=2.5U L=0.06U M=1 $name=/giogtpinv1/N00
M362 VDD NET818 IOGTPN VDD PCH W=5U L=0.06U M=1 $name=/giogtpinv1/P00
M363 NET819 NET606 VSS VSS NCH W=1.84U L=0.06U M=1 $name=/ginv1/N00
M364 VDD NET606 NET819 VDD PCH W=2.5U L=0.06U M=1 $name=/ginv1/P00
M365 IOGTPL IOGTPN VSS VSS NCH W=5U L=0.06U M=1 $name=/I53/N00
M366 VDD IOGTPN IOGTPL VDD PCH W=10U L=0.06U M=1 $name=/I53/P00
M367 YP1_0 NET678 VSS VSS NCH W=5U L=0.06U M=1 $name=/I41/N00
M368 VDD NET678 YP1_0 VDD PCH W=10U L=0.06U M=1 $name=/I41/P00
M369 YP1_2 NET826 VSS VSS NCH W=5U L=0.06U M=1 $name=/I40/N00
M37 NET681 AY3 HNET208 VSS NCH W=1.25U L=0.06U M=1 $name=/I36/N00
M370 VDD NET826 YP1_2 VDD PCH W=10U L=0.06U M=1 $name=/I40/P00
M371 YP1_1 NET681 VSS VSS NCH W=5U L=0.06U M=1 $name=/I39/N00
M372 VDD NET681 YP1_1 VDD PCH W=10U L=0.06U M=1 $name=/I39/P00
M373 TIELOW TIEHIGH VSS VSS NCH W=0.9U L=0.06U M=1 $name=/I140/N00
M374 VDD TIEHIGH TIELOW VDD PCH W=0.9U L=0.06U M=1 $name=/I140/P00
M375 CLKB CLK VSS VSS NCH W=8.76U L=0.06U M=1 $name=/I127/N00
M376 VDD CLK CLKB VDD PCH W=13.2U L=0.06U M=1 $name=/I127/P00
M377 FIOGTPL DELAYEDMBL VSS VSS NCH W=5U L=0.06U M=1 $name=/I110/N00
M378 VDD DELAYEDMBL FIOGTPL VDD PCH W=10U L=0.06U M=1 $name=/I110/P00
M379 NET389 RETN VSS VSS NCH W=0.4U L=0.06U M=1 $name=/I0/N00
M38 VDD NET679 NET681 VDD PCH W=2.5U L=0.06U M=1 $name=/I36/P10
M380 VDD RETN NET389 VDD PCH W=0.8U L=0.06U M=1 $name=/I0/P00
M39 VDD AY3 NET681 VDD PCH W=2.5U L=0.06U M=1 $name=/I36/P00
M4 HNET184 GTP VSS VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N11
M40 HNET215 AY4 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I35/N11
M41 NET826 NET677 HNET215 VSS NCH W=1.25U L=0.06U M=1 $name=/I35/N10
M42 HNET213 AY4 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I35/N01
M43 NET826 NET677 HNET213 VSS NCH W=1.25U L=0.06U M=1 $name=/I35/N00
M44 VDD AY4 NET826 VDD PCH W=2.5U L=0.06U M=1 $name=/I35/P10
M45 VDD NET677 NET826 VDD PCH W=2.5U L=0.06U M=1 $name=/I35/P00
M46 NET767 MWLLATE VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I33/N10
M47 NET767 GTP VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I33/N00
M48 VDD MWLLATE HNET217 VDD PCH W=0.8U L=0.06U M=1 $name=/I33/P01
M49 HNET217 GTP NET767 VDD PCH W=0.8U L=0.06U M=1 $name=/I33/P00
M5 DELAYEDMBL NET819 HNET184 VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N10
M50 NET776 NET389 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tiretnnor/N10
M51 NET776 NET390 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tiretnnor/N00
M52 VDD NET389 HNET221 VDD PCH W=0.25U L=0.06U M=1 $name=/tiretnnor/P01
M53 HNET221 NET390 NET776 VDD PCH W=0.25U L=0.06U M=1 $name=/tiretnnor/P00
M54 AB IRET VSS VSS NCH W=0.3U L=0.06U M=1 $name=/tabdrv/N10
M55 AB CLKCE VSS VSS NCH W=0.3U L=0.06U M=1 $name=/tabdrv/N00
M56 VDD IRET HNET225 VDD PCH W=1.2U L=0.06U M=1 $name=/tabdrv/P01
M57 HNET225 CLKCE AB VDD PCH W=1.2U L=0.06U M=1 $name=/tabdrv/P00
M58 PIOGTPN GTPDED VSS VSS NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N20
M59 PIOGTPN GTPDS VSS VSS NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N10
M6 HNET179 GTP VSS VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N01
M60 PIOGTPN GTP VSS VSS NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N00
M61 VDD GTPDED HNET234 VDD PCH W=1U L=0.06U M=1 $name=/giogtpnor/P02
M62 HNET234 GTPDS HNET231 VDD PCH W=1U L=0.06U M=1 $name=/giogtpnor/P01
M63 HNET231 GTP PIOGTPN VDD PCH W=1U L=0.06U M=1 $name=/giogtpnor/P00
M64 HNET239 EMA0N VSS VSS NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N02
M65 HNET240 EMA1N HNET239 VSS NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N01
M66 EMA000N EMA2N HNET240 VSS NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N00
M67 VDD EMA0N EMA000N VDD PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P20
M68 VDD EMA1N EMA000N VDD PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P10
M69 VDD EMA2N EMA000N VDD PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P00
M7 DELAYEDMBL NET819 HNET179 VSS NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N00
M70 MBLSEL EMA000N VSS VSS NCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel1/N10
M71 MBLSEL STOVI VSS VSS NCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel1/N00
M72 VDD EMA000N HNET241 VDD PCH_HVT W=0.8U L=0.06U M=1 $name=/mblsel1/P01
M73 HNET241 STOVI MBLSEL VDD PCH_HVT W=0.8U L=0.06U M=1 $name=/mblsel1/P00
M74 NET405 EMA2N VSS VSS NCH_HVT W=0.52U L=0.06U M=1 $name=/dlynord1/N10
M75 NET405 NET407 VSS VSS NCH_HVT W=0.52U L=0.06U M=1 $name=/dlynord1/N00
M76 VDD EMA2N HNET245 VDD PCH_HVT W=1.43U L=0.06U M=1 $name=/dlynord1/P01
M77 HNET245 NET407 NET405 VDD PCH_HVT W=1.43U L=0.06U M=1 $name=/dlynord1/P00
M78 VDD CKI SETGTP VDD PCH_HVT W=0.75U L=0.06U M=1 $name=/tgtpen/P00
M79 VDD GTP VDD VDD PCH_HVT W=0.3U L=0.12U M=1 $name=/tdlyp3b/P00
M8 VDD GTP DELAYEDMBL VDD PCH W=8U L=0.06U M=1 $name=/gfiogtpnd/P10
M80 NET407 EMA00B EMAPRE VDD PCH_HVT W=0.89U L=0.06U M=1 $name=/dlypassp/P00
M81 NET419 TIELOW NET578 VDD PCH_HVT W=0.45U L=0.12U M=1 $name=/P7/P00
M82 VDD TIELOW NET419 VDD PCH_HVT W=0.45U L=0.12U M=1 $name=/P6/P00
M83 NET514 EMA11B EMAPRE VDD PCH_HVT W=0.89U L=0.06U M=1 $name=/P29/P00
M84 NET700 EMA10B EMAPRE VDD PCH_HVT W=0.89U L=0.06U M=1 $name=/P28/P00
M85 NET703 EMA01B EMAPRE VDD PCH_HVT W=0.89U L=0.06U M=1 $name=/P25/P00
M86 VDD SETGTP GTP VDD PCH W=3U L=0.06U M=1 $name=/P13/P00
M87 VDD SETGTP GTP VDD PCH W=3U L=0.06U M=1 $name=/P12/P00
M88 VDD SETGTP GTP VDD PCH W=3U L=0.06U M=1 $name=/P11/P00
M89 VDD GTPDEI NET0418 VDD PCH W=0.45U L=0.06U M=1 $name=/P15/P00
M9 VDD NET819 DELAYEDMBL VDD PCH W=8U L=0.06U M=1 $name=/gfiogtpnd/P00
M90 VDD SETGTP GTP VDD PCH W=3U L=0.06U M=1 $name=/P10/P00
M91 VDD GTPDEI VDD VDD PCH W=0.45U L=0.12U M=1 $name=/P14/P00
M92 VDD SETGTP GTP VDD PCH W=3U L=0.06U M=1 $name=/P9/P00
M93 WELOUT AGTP WEI VDD PCH W=0.36U L=0.06U M=1 $name=/tpgwep4/P00
M94 RGWEB AGTPN NET810 VDD PCH W=0.15U L=0.06U M=1 $name=/tpgwep3/P00
M95 NET610 AGTP RGWEB VDD PCH W=0.15U L=0.06U M=1 $name=/tpgwep2/P00
M96 NET536 AGTPN WELOUT VDD PCH W=0.15U L=0.06U M=1 $name=/tpgwep1/P00
M97 VDD DELAYEDGTP MBL VDD PCH W=3U L=0.06U M=1 $name=/tkpmbl/P00
M98 VDD A SETGTP VDD PCH W=9.3U L=0.06U M=1 $name=/tgtpset/P00
M99 VDD SETGTP GTP VDD PCH W=3U L=0.06U M=1 $name=/tgtpdrvp/P00
.ENDS sram_ACTRL
****
.SUBCKT sram_AAL A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N A13N
+  AGTP AGTPN AI5 AI6 AI7 AI8 AI9 AI10 AI11 AI12 AI13 AX0N AX1N AX2N AX3N AX4N
+  AX5N AX6N AY0N AY1N AY2N AY3 AY4 BS0N BS1N BSN_MSB CE_WE_TRACK FIOGTP_TRACK
+  IOGTP_TRACK LAT11 LAT12 LAT13 MATCH0 MATCH1 MATCH2 MATCH3 RETN_TRACK
+  RET_TRACK RREN RXP0 RXP1 RXP2 RXP3 TIEHIGH TIELOW YP0_TRACK YP1_TRACK
+  YP2_TRACK YP3_TRACK VSS VDD
** sram_AAL: 192 flat devices **
M0 HNET126 NET332 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I6/NI00
M1 NET331 AGTP HNET126 VSS NCH W=0.2U L=0.06U M=1 $name=/I6/NE00
M10 HNET134 AGTPN NET518 VDD PCH W=0.3U L=0.06U M=1 $name=/I7/PE00
M100 RXP1 NET503 VSS VSS NCH W=1U L=0.06U M=1 $name=/I5/N00
M101 VDD NET503 RXP1 VDD PCH W=2U L=0.06U M=1 $name=/I5/P00
M102 RXP0 NET507 VSS VSS NCH W=1U L=0.06U M=1 $name=/trra/N00
M103 VDD NET507 RXP0 VDD PCH W=2U L=0.06U M=1 $name=/trra/P00
M104 RXP3 NET501 VSS VSS NCH W=1U L=0.06U M=1 $name=/I1/N00
M105 VDD NET501 RXP3 VDD PCH W=2U L=0.06U M=1 $name=/I1/P00
M106 RXP2 NET505 VSS VSS NCH W=1U L=0.06U M=1 $name=/I2/N00
M107 VDD NET505 RXP2 VDD PCH W=2U L=0.06U M=1 $name=/I2/P00
M108 AI12 NET518 VSS VSS NCH W=2U L=0.06U M=1 $name=/I96/N00
M109 VDD NET518 AI12 VDD PCH W=4U L=0.06U M=1 $name=/I96/P00
M11 VDD NET529 HNET134 VDD PCH W=0.3U L=0.06U M=1 $name=/I7/PI00
M110 AY1N NET348 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I30/N00
M111 VDD NET348 AY1N VDD PCH W=7.04U L=0.06U M=1 $name=/I30/P00
M112 RREN NET522 VSS VSS NCH W=4.5U L=0.06U M=1 $name=/trrendrv/N00
M113 VDD NET522 RREN VDD PCH W=9U L=0.06U M=1 $name=/trrendrv/P00
M114 AI13 NET331 VSS VSS NCH W=2U L=0.06U M=1 $name=/trre/N00
M115 VDD NET331 AI13 VDD PCH W=4U L=0.06U M=1 $name=/trre/P00
M116 NET332 NET331 VSS VSS NCH W=1U L=0.06U M=1 $name=/taddrdrvb/N00
M117 VDD NET331 NET332 VDD PCH W=2U L=0.06U M=1 $name=/taddrdrvb/P00
M118 LAT13 NET332 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/taddrdrv/N00
M119 VDD NET332 LAT13 VDD PCH W=7.04U L=0.06U M=1 $name=/taddrdrv/P00
M12 HNET147 NET344 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I11/NI00
M120 NET529 NET518 VSS VSS NCH W=1U L=0.06U M=1 $name=/gaidriveb/N00
M121 VDD NET518 NET529 VDD PCH W=2U L=0.06U M=1 $name=/gaidriveb/P00
M122 NET531 BSN_MSB VSS VSS NCH W=1.2U L=0.06U M=1 $name=/grrinv3/N00
M123 VDD BSN_MSB NET531 VDD PCH W=2U L=0.06U M=1 $name=/grrinv3/P00
M124 NET533 BSN_MSB VSS VSS NCH W=1.2U L=0.06U M=1 $name=/grrinv2/N00
M125 VDD BSN_MSB NET533 VDD PCH W=2U L=0.06U M=1 $name=/grrinv2/P00
M126 NET535 MATCH1 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/grrinv1/N00
M127 VDD MATCH1 NET535 VDD PCH W=0.2U L=0.06U M=1 $name=/grrinv1/P00
M128 LAT12 NET529 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/gaidrive/N00
M129 VDD NET529 LAT12 VDD PCH W=7.04U L=0.06U M=1 $name=/gaidrive/P00
M13 NET582 AGTP HNET147 VSS NCH W=0.2U L=0.06U M=1 $name=/I11/NE00
M130 LAT11 NET344 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I9/N00
M131 VDD NET344 LAT11 VDD PCH W=7.04U L=0.06U M=1 $name=/I9/P00
M132 NET541 MATCH2 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I70/N00
M133 VDD MATCH2 NET541 VDD PCH W=0.2U L=0.06U M=1 $name=/I70/P00
M134 NET543 MATCH3 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I69/N00
M135 VDD MATCH3 NET543 VDD PCH W=0.2U L=0.06U M=1 $name=/I69/P00
M136 NET545 MATCH0 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I3/N00
M137 VDD MATCH0 NET545 VDD PCH W=0.2U L=0.06U M=1 $name=/I3/P00
M138 NET547 NET479 VSS VSS NCH W=1U L=0.06U M=1 $name=/I63/N00
M139 VDD NET479 NET547 VDD PCH W=2U L=0.06U M=1 $name=/I63/P00
M14 HNET141 AGTPN NET582 VDD PCH W=0.3U L=0.06U M=1 $name=/I11/PE00
M140 AI5 NET550 VSS VSS NCH W=2U L=0.06U M=1 $name=/I62/N00
M141 VDD NET550 AI5 VDD PCH W=4U L=0.06U M=1 $name=/I62/P00
M142 AXL0 NET550 VSS VSS NCH W=1U L=0.06U M=1 $name=/I60/N00
M143 VDD NET550 AXL0 VDD PCH W=2U L=0.06U M=1 $name=/I60/P00
M144 AI7 NET554 VSS VSS NCH W=2U L=0.06U M=1 $name=/I56/N00
M145 VDD NET554 AI7 VDD PCH W=4U L=0.06U M=1 $name=/I56/P00
M146 AI6 NET467 VSS VSS NCH W=2U L=0.06U M=1 $name=/I59/N00
M147 VDD NET467 AI6 VDD PCH W=4U L=0.06U M=1 $name=/I59/P00
M148 NET360 NET554 VSS VSS NCH W=1U L=0.06U M=1 $name=/I54/N00
M149 VDD NET554 NET360 VDD PCH W=2U L=0.06U M=1 $name=/I54/P00
M15 VDD NET344 HNET141 VDD PCH W=0.3U L=0.06U M=1 $name=/I11/PI00
M150 AX2N NET360 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I19/N00
M151 VDD NET360 AX2N VDD PCH W=7.04U L=0.06U M=1 $name=/I19/P00
M152 NET561 NET467 VSS VSS NCH W=1U L=0.06U M=1 $name=/I57/N00
M153 VDD NET467 NET561 VDD PCH W=2U L=0.06U M=1 $name=/I57/P00
M154 AX1N NET561 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I18/N00
M155 VDD NET561 AX1N VDD PCH W=7.04U L=0.06U M=1 $name=/I18/P00
M156 AI8 NET485 VSS VSS NCH W=2U L=0.06U M=1 $name=/I53/N00
M157 VDD NET485 AI8 VDD PCH W=4U L=0.06U M=1 $name=/I53/P00
M158 NET567 NET485 VSS VSS NCH W=1U L=0.06U M=1 $name=/I51/N00
M159 VDD NET485 NET567 VDD PCH W=2U L=0.06U M=1 $name=/I51/P00
M16 HNET154 NET348 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I22/NI00
M160 NET364 NET572 VSS VSS NCH W=1U L=0.06U M=1 $name=/I50/N00
M161 VDD NET572 NET364 VDD PCH W=2U L=0.06U M=1 $name=/I50/P00
M162 AI9 NET572 VSS VSS NCH W=2U L=0.06U M=1 $name=/I48/N00
M163 VDD NET572 AI9 VDD PCH W=4U L=0.06U M=1 $name=/I48/P00
M164 NET348 NET347 VSS VSS NCH W=1U L=0.06U M=1 $name=/I65/N00
M165 VDD NET347 NET348 VDD PCH W=2U L=0.06U M=1 $name=/I65/P00
M166 AI10 NET491 VSS VSS NCH W=2U L=0.06U M=1 $name=/I43/N00
M167 VDD NET491 AI10 VDD PCH W=4U L=0.06U M=1 $name=/I43/P00
M168 NET577 NET491 VSS VSS NCH W=1U L=0.06U M=1 $name=/I42/N00
M169 VDD NET491 NET577 VDD PCH W=2U L=0.06U M=1 $name=/I42/P00
M17 NET347 AGTP HNET154 VSS NCH W=0.2U L=0.06U M=1 $name=/I22/NE00
M170 NET344 NET582 VSS VSS NCH W=1U L=0.06U M=1 $name=/I40/N00
M171 VDD NET582 NET344 VDD PCH W=2U L=0.06U M=1 $name=/I40/P00
M172 AI11 NET582 VSS VSS NCH W=2U L=0.06U M=1 $name=/I39/N00
M173 VDD NET582 AI11 VDD PCH W=4U L=0.06U M=1 $name=/I39/P00
M174 AYL0 AY0NLOUT VSS VSS NCH W=1U L=0.06U M=1 $name=/I46/N00
M175 VDD AY0NLOUT AYL0 VDD PCH W=2U L=0.06U M=1 $name=/I46/P00
M176 AY0N AYL0 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I31/N00
M177 VDD AYL0 AY0N VDD PCH W=7.04U L=0.06U M=1 $name=/I31/P00
M178 AY3 A3N VSS VSS NCH W=1.2U L=0.06U M=1 $name=/I27/N00
M179 VDD A3N AY3 VDD PCH W=2.4U L=0.06U M=1 $name=/I27/P00
M18 HNET148 AGTPN NET347 VDD PCH W=0.3U L=0.06U M=1 $name=/I22/PE00
M180 AY4 A4N VSS VSS NCH W=1.2U L=0.06U M=1 $name=/I26/N00
M181 VDD A4N AY4 VDD PCH W=2.4U L=0.06U M=1 $name=/I26/P00
M182 AY2N NET547 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I25/N00
M183 VDD NET547 AY2N VDD PCH W=7.04U L=0.06U M=1 $name=/I25/P00
M184 AX0N AXL0 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I24/N00
M185 VDD AXL0 AX0N VDD PCH W=7.04U L=0.06U M=1 $name=/I24/P00
M186 AX3N NET567 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I17/N00
M187 VDD NET567 AX3N VDD PCH W=7.04U L=0.06U M=1 $name=/I17/P00
M188 AX4N NET364 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I16/N00
M189 VDD NET364 AX4N VDD PCH W=7.04U L=0.06U M=1 $name=/I16/P00
M19 VDD NET348 HNET148 VDD PCH W=0.3U L=0.06U M=1 $name=/I22/PI00
M190 AX5N NET577 VSS VSS NCH W=3.52U L=0.06U M=1 $name=/I10/N00
M191 VDD NET577 AX5N VDD PCH W=7.04U L=0.06U M=1 $name=/I10/P00
M2 HNET120 AGTPN NET331 VDD PCH W=0.3U L=0.06U M=1 $name=/I6/PE00
M20 HNET161 NET547 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I23/NI00
M21 NET479 AGTP HNET161 VSS NCH W=0.2U L=0.06U M=1 $name=/I23/NE00
M22 HNET155 AGTPN NET479 VDD PCH W=0.3U L=0.06U M=1 $name=/I23/PE00
M23 VDD NET547 HNET155 VDD PCH W=0.3U L=0.06U M=1 $name=/I23/PI00
M24 HNET168 AXL0 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I20/NI00
M25 NET550 AGTP HNET168 VSS NCH W=0.2U L=0.06U M=1 $name=/I20/NE00
M26 HNET162 AGTPN NET550 VDD PCH W=0.3U L=0.06U M=1 $name=/I20/PE00
M27 VDD AXL0 HNET162 VDD PCH W=0.3U L=0.06U M=1 $name=/I20/PI00
M28 HNET175 NET360 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I14/NI00
M29 NET554 AGTP HNET175 VSS NCH W=0.2U L=0.06U M=1 $name=/I14/NE00
M3 VDD NET332 HNET120 VDD PCH W=0.3U L=0.06U M=1 $name=/I6/PI00
M30 HNET169 AGTPN NET554 VDD PCH W=0.3U L=0.06U M=1 $name=/I14/PE00
M31 VDD NET360 HNET169 VDD PCH W=0.3U L=0.06U M=1 $name=/I14/PI00
M32 HNET182 NET364 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I12/NI00
M33 NET572 AGTP HNET182 VSS NCH W=0.2U L=0.06U M=1 $name=/I12/NE00
M34 HNET176 AGTPN NET572 VDD PCH W=0.3U L=0.06U M=1 $name=/I12/PE00
M35 VDD NET364 HNET176 VDD PCH W=0.3U L=0.06U M=1 $name=/I12/PI00
M36 HNET189 NET567 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I15/NI00
M37 NET485 AGTP HNET189 VSS NCH W=0.2U L=0.06U M=1 $name=/I15/NE00
M38 HNET183 AGTPN NET485 VDD PCH W=0.3U L=0.06U M=1 $name=/I15/PE00
M39 VDD NET567 HNET183 VDD PCH W=0.3U L=0.06U M=1 $name=/I15/PI00
M4 HNET133 AYL0 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I28/NI00
M40 HNET196 NET561 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I21/NI00
M41 NET467 AGTP HNET196 VSS NCH W=0.2U L=0.06U M=1 $name=/I21/NE00
M42 HNET190 AGTPN NET467 VDD PCH W=0.3U L=0.06U M=1 $name=/I21/PE00
M43 VDD NET561 HNET190 VDD PCH W=0.3U L=0.06U M=1 $name=/I21/PI00
M44 HNET203 NET577 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I13/NI00
M45 NET491 AGTP HNET203 VSS NCH W=0.2U L=0.06U M=1 $name=/I13/NE00
M46 HNET197 AGTPN NET491 VDD PCH W=0.3U L=0.06U M=1 $name=/I13/PE00
M47 VDD NET577 HNET197 VDD PCH W=0.3U L=0.06U M=1 $name=/I13/PI00
M48 HNET206 NET463 VSS VSS NCH W=3.5U L=0.06U M=1 $name=/trrnand/N01
M49 NET522 NET472 HNET206 VSS NCH W=3.5U L=0.06U M=1 $name=/trrnand/N00
M5 AY0NLOUT AGTP HNET133 VSS NCH W=0.2U L=0.06U M=1 $name=/I28/NE00
M50 VDD NET463 NET522 VDD PCH W=2.92U L=0.06U M=1 $name=/trrnand/P10
M51 VDD NET472 NET522 VDD PCH W=2.92U L=0.06U M=1 $name=/trrnand/P00
M52 NET467 AGTP A6N VDD PCH W=2U L=0.06U M=1 $name=/P36/P00
M53 NET533 NET535 NET463 VDD PCH W=1.2U L=0.06U M=1 $name=/trrpgp/P00
M54 NET533 NET545 NET463 VDD PCH W=1.2U L=0.06U M=1 $name=/P8/P00
M55 NET392 MATCH0 NET463 VDD PCH W=2U L=0.06U M=1 $name=/trrpu/P00
M56 VDD TIELOW TIEHIGH VDD PCH W=4.5U L=0.06U M=1 $name=/tarefp/P00
M57 NET331 AGTP A13N VDD PCH W=2U L=0.06U M=1 $name=/tapgp/P00
M58 NET550 AGTP A5N VDD PCH W=2U L=0.06U M=1 $name=/taiop2/P00
M59 AY0NLOUT AGTP A0N VDD PCH W=2U L=0.06U M=1 $name=/taiop/P00
M6 HNET127 AGTPN AY0NLOUT VDD PCH W=0.3U L=0.06U M=1 $name=/I28/PE00
M60 VDD MATCH1 NET392 VDD PCH W=2U L=0.06U M=1 $name=/P5/P00
M61 VDD TIEHIGH TIEHIGH VDD PCH W=0.15U L=0.06U M=1 $name=/P79/P00
M62 VDD MATCH3 NET416 VDD PCH W=2U L=0.06U M=1 $name=/P4/P00
M63 NET416 MATCH2 NET472 VDD PCH W=2U L=0.06U M=1 $name=/P3/P00
M64 NET531 NET543 NET472 VDD PCH W=1.2U L=0.06U M=1 $name=/P2/P00
M65 NET531 NET541 NET472 VDD PCH W=1.2U L=0.06U M=1 $name=/P1/P00
M66 NET347 AGTP A1N VDD PCH W=2U L=0.06U M=1 $name=/P42/P00
M67 NET479 AGTP A2N VDD PCH W=2U L=0.06U M=1 $name=/P40/P00
M68 NET554 AGTP A7N VDD PCH W=2U L=0.06U M=1 $name=/P34/P00
M69 NET485 AGTP A8N VDD PCH W=2U L=0.06U M=1 $name=/P32/P00
M7 VDD AYL0 HNET127 VDD PCH W=0.3U L=0.06U M=1 $name=/I28/PI00
M70 NET572 AGTP A9N VDD PCH W=2U L=0.06U M=1 $name=/P30/P00
M71 NET491 AGTP A10N VDD PCH W=2U L=0.06U M=1 $name=/P27/P00
M72 NET582 AGTP A11N VDD PCH W=2U L=0.06U M=1 $name=/P26/P00
M73 NET518 AGTP A12N VDD PCH W=2U L=0.06U M=1 $name=/P19/P00
M74 TIELOW TIEHIGH VSS VSS NCH W=3.3U L=0.06U M=1 $name=/tarefn/N00
M75 NET331 AGTPN A13N VSS NCH W=2U L=0.06U M=1 $name=/tapgn/N00
M76 NET550 AGTPN A5N VSS NCH W=2U L=0.06U M=1 $name=/taion2/N00
M77 AY0NLOUT AGTPN A0N VSS NCH W=2U L=0.06U M=1 $name=/taion/N00
M78 NET533 MATCH1 NET463 VSS NCH W=1.2U L=0.06U M=1 $name=/trrpgn/N00
M79 NET533 MATCH0 NET463 VSS NCH W=1.2U L=0.06U M=1 $name=/N4/N00
M8 HNET140 NET529 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I7/NI00
M80 NET467 AGTPN A6N VSS NCH W=2U L=0.06U M=1 $name=/N37/N00
M81 NET531 MATCH3 NET472 VSS NCH W=1.2U L=0.06U M=1 $name=/N2/N00
M82 NET531 MATCH2 NET472 VSS NCH W=1.2U L=0.06U M=1 $name=/N1/N00
M83 NET347 AGTPN A1N VSS NCH W=2U L=0.06U M=1 $name=/N43/N00
M84 NET479 AGTPN A2N VSS NCH W=2U L=0.06U M=1 $name=/N41/N00
M85 NET554 AGTPN A7N VSS NCH W=2U L=0.06U M=1 $name=/N35/N00
M86 NET485 AGTPN A8N VSS NCH W=2U L=0.06U M=1 $name=/N33/N00
M87 NET572 AGTPN A9N VSS NCH W=2U L=0.06U M=1 $name=/N31/N00
M88 NET491 AGTPN A10N VSS NCH W=2U L=0.06U M=1 $name=/N28/N00
M89 NET582 AGTPN A11N VSS NCH W=2U L=0.06U M=1 $name=/N27/N00
M9 NET518 AGTP HNET140 VSS NCH W=0.2U L=0.06U M=1 $name=/I7/NE00
M90 TIELOW TIELOW VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N20/N00
M91 NET518 AGTPN A12N VSS NCH W=2U L=0.06U M=1 $name=/N19/N00
M92 NET501 MATCH3 VSS VSS NCH W=0.45U L=0.06U M=1 $name=/I94/N00
M93 VDD MATCH3 NET501 VDD PCH W=0.7U L=0.06U M=1 $name=/I94/P00
M94 NET503 MATCH1 VSS VSS NCH W=0.45U L=0.06U M=1 $name=/I4/N00
M95 VDD MATCH1 NET503 VDD PCH W=0.7U L=0.06U M=1 $name=/I4/P00
M96 NET505 MATCH2 VSS VSS NCH W=0.45U L=0.06U M=1 $name=/I0/N00
M97 VDD MATCH2 NET505 VDD PCH W=0.7U L=0.06U M=1 $name=/I0/P00
M98 NET507 MATCH0 VSS VSS NCH W=0.45U L=0.06U M=1 $name=/trran/N00
M99 VDD MATCH0 NET507 VDD PCH W=0.7U L=0.06U M=1 $name=/trran/P00
.ENDS sram_AAL
****
.SUBCKT sram_ABCTRL32M8 A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N
+  A13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0N BS1N CEI CE_WE
+  CLK CREN_TERM_0 CREN_TERM_1 EMA0 EMA1 EMA2 FIOGTP FIOGTPR GDLA_TERM
+  GDLA__TERM GDL_TERM GDL__TERM GTP GTPDET GTPDST IOGTP IOGTPR LGWEN MATCH0
+  MATCH1 MATCH2 MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE PG_TERM_0 PG_TERM_1
+  PRDT PWBT RDT RETN RETN_TRACK RET_TRACK RRENDD RXP0 RXP1 RXP2 RXP3 STOV
+  T0L_TERM TIEHIGH_0 TIEHIGH_1 TIELOW_0 TIELOW_1 TL0_TERM WBTDD WEI WE_TERM_0
+  WE_TERM_1 YP0_TRACK YP1_TRACK YP2_TRACK YP3_TRACK YSNA_TERM_0 YSNA_TERM_1
+  VSS VDD
** sram_ABCTRL32M8: 575 flat devices **
XINSTAL A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N A13N AGTP AGTPN
+  AI5 AI6 AI7 AI8 AI9 AI10 AI11 AI12 AI13 AX0N AX1N AX2N AX3N AX4N AX5N AX6N
+  AY0N AY1N AY2N AY3 AY4 BS0N BS1N TIEHIGH_1 CE_WE FIOGTP IOGTP BS0N BS1N
+  AX6N MATCH0 MATCH1 MATCH2 MATCH3 RETN_TRACK RET_TRACK RRENDD RXP0 RXP1 RXP2
+  RXP3 TIEHIGH_1 TIELOW_1 YP0_TRACK YP1_TRACK YP2_TRACK YP3_TRACK VSS VDD
+  sram_AAL
XINSTCTRL AGTP AGTPN AX6N AY3 AY4 BS0N BS1N CEI CE_WE CLK CREN_TERM_1 EMA0
+  EMA1 EMA2 FIOGTP FIOGTPR GDLA_TERM GDLA__TERM GTP GTPDST GTPDEI GTPDET
+  GTPDST GTPDEI GTPDST IOGTP IOGTPR RET_TRACK RETN_TRACK LGWEN MBL MGDLE
+  MGDLET MGDLE MGDLST MGTPS MWLLATE PG_TERM_1 PRDT PWBT RDT RETN RRENDD STOV
+  TIEHIGH_0 TIELOW_0 TL0_TERM WBTDD WEI WE_TERM_1 YP0_TRACK YP1_TRACK
+  YP2_TRACK YP3_TRACK YSNA_TERM_1 VSS VDD sram_ACTRL
.ENDS sram_ABCTRL32M8
****
.SUBCKT sram_AIO8RL16 BLTERM0_0 BLTERM0_1 BLTERM0_2 BLTERM0_3 BLTERM0_4
+  BLTERM0_5 BLTERM0_6 BLTERM0_7 BLTERM0_8 BLTERM0_9 BLTERM0_10 BLTERM0_11
+  BLTERM0_12 BLTERM0_13 BLTERM0_14 BLTERM0_15 BLTERM0__0 BLTERM0__1
+  BLTERM0__2 BLTERM0__3 BLTERM0__4 BLTERM0__5 BLTERM0__6 BLTERM0__7
+  BLTERM0__8 BLTERM0__9 BLTERM0__10 BLTERM0__11 BLTERM0__12 BLTERM0__13
+  BLTERM0__14 BLTERM0__15 BLTERM1_0 BLTERM1_1 BLTERM1_2 BLTERM1_3 BLTERM1_4
+  BLTERM1_5 BLTERM1_6 BLTERM1_7 BLTERM1_8 BLTERM1_9 BLTERM1_10 BLTERM1_11
+  BLTERM1_12 BLTERM1_13 BLTERM1_14 BLTERM1_15 BLTERM1__0 BLTERM1__1
+  BLTERM1__2 BLTERM1__3 BLTERM1__4 BLTERM1__5 BLTERM1__6 BLTERM1__7
+  BLTERM1__8 BLTERM1__9 BLTERM1__10 BLTERM1__11 BLTERM1__12 BLTERM1__13
+  BLTERM1__14 BLTERM1__15 BLTERM2_0 BLTERM2_1 BLTERM2_2 BLTERM2_3 BLTERM2_4
+  BLTERM2_5 BLTERM2_6 BLTERM2_7 BLTERM2_8 BLTERM2_9 BLTERM2_10 BLTERM2_11
+  BLTERM2_12 BLTERM2_13 BLTERM2_14 BLTERM2_15 BLTERM2__0 BLTERM2__1
+  BLTERM2__2 BLTERM2__3 BLTERM2__4 BLTERM2__5 BLTERM2__6 BLTERM2__7
+  BLTERM2__8 BLTERM2__9 BLTERM2__10 BLTERM2__11 BLTERM2__12 BLTERM2__13
+  BLTERM2__14 BLTERM2__15 BLTERM3_0 BLTERM3_1 BLTERM3_2 BLTERM3_3 BLTERM3_4
+  BLTERM3_5 BLTERM3_6 BLTERM3_7 BLTERM3_8 BLTERM3_9 BLTERM3_10 BLTERM3_11
+  BLTERM3_12 BLTERM3_13 BLTERM3_14 BLTERM3_15 BLTERM3__0 BLTERM3__1
+  BLTERM3__2 BLTERM3__3 BLTERM3__4 BLTERM3__5 BLTERM3__6 BLTERM3__7
+  BLTERM3__8 BLTERM3__9 BLTERM3__10 BLTERM3__11 BLTERM3__12 BLTERM3__13
+  BLTERM3__14 BLTERM3__15 BLTERM4_0 BLTERM4_1 BLTERM4_2 BLTERM4_3 BLTERM4_4
+  BLTERM4_5 BLTERM4_6 BLTERM4_7 BLTERM4_8 BLTERM4_9 BLTERM4_10 BLTERM4_11
+  BLTERM4_12 BLTERM4_13 BLTERM4_14 BLTERM4_15 BLTERM4__0 BLTERM4__1
+  BLTERM4__2 BLTERM4__3 BLTERM4__4 BLTERM4__5 BLTERM4__6 BLTERM4__7
+  BLTERM4__8 BLTERM4__9 BLTERM4__10 BLTERM4__11 BLTERM4__12 BLTERM4__13
+  BLTERM4__14 BLTERM4__15 BLTERM5_0 BLTERM5_1 BLTERM5_2 BLTERM5_3 BLTERM5_4
+  BLTERM5_5 BLTERM5_6 BLTERM5_7 BLTERM5_8 BLTERM5_9 BLTERM5_10 BLTERM5_11
+  BLTERM5_12 BLTERM5_13 BLTERM5_14 BLTERM5_15 BLTERM5__0 BLTERM5__1
+  BLTERM5__2 BLTERM5__3 BLTERM5__4 BLTERM5__5 BLTERM5__6 BLTERM5__7
+  BLTERM5__8 BLTERM5__9 BLTERM5__10 BLTERM5__11 BLTERM5__12 BLTERM5__13
+  BLTERM5__14 BLTERM5__15 BLTERM6_0 BLTERM6_1 BLTERM6_2 BLTERM6_3 BLTERM6_4
+  BLTERM6_5 BLTERM6_6 BLTERM6_7 BLTERM6_8 BLTERM6_9 BLTERM6_10 BLTERM6_11
+  BLTERM6_12 BLTERM6_13 BLTERM6_14 BLTERM6_15 BLTERM6__0 BLTERM6__1
+  BLTERM6__2 BLTERM6__3 BLTERM6__4 BLTERM6__5 BLTERM6__6 BLTERM6__7
+  BLTERM6__8 BLTERM6__9 BLTERM6__10 BLTERM6__11 BLTERM6__12 BLTERM6__13
+  BLTERM6__14 BLTERM6__15 BLTERM7_0 BLTERM7_1 BLTERM7_2 BLTERM7_3 BLTERM7_4
+  BLTERM7_5 BLTERM7_6 BLTERM7_7 BLTERM7_8 BLTERM7_9 BLTERM7_10 BLTERM7_11
+  BLTERM7_12 BLTERM7_13 BLTERM7_14 BLTERM7_15 BLTERM7__0 BLTERM7__1
+  BLTERM7__2 BLTERM7__3 BLTERM7__4 BLTERM7__5 BLTERM7__6 BLTERM7__7
+  BLTERM7__8 BLTERM7__9 BLTERM7__10 BLTERM7__11 BLTERM7__12 BLTERM7__13
+  BLTERM7__14 BLTERM7__15 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6
+  BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 CE_WE
+  CREN_0 CREN_1 CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7 CREN_8 CREN_9
+  CREN_10 CREN_11 CREN_12 CREN_13 CREN_14 CREN_15 DNI_0 DNI_1 DNI_2 DNI_3
+  DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14
+  DNI_15 FIOGTP GDLA GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL__0 GDL__1 GDL__2 GDL__3
+  GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13
+  GDL__14 GDL__15 IOGTP IRET IRETN Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7
+  Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 TIEHIGH TIELOW YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** sram_AIO8RL16: 2756 flat devices **
XLEFTIO0 BLTERM0_0 BLTERM0__0 BLTERM1_0 BLTERM1__0 BLTERM2_0 BLTERM2__0
+  BLTERM3_0 BLTERM3__0 BLTERM4_0 BLTERM4__0 BLTERM5_0 BLTERM5__0 BLTERM6_0
+  BLTERM6__0 BLTERM7_0 BLTERM7__0 BWEI_0 CE_WE CREN_0 TIEHIGH TIEHIGH TIEHIGH
+  DNI_0 FIOGTP GDL_0 GDLA TIEHIGH GDLA TIEHIGH GDLI_66 GDLI__68 GDL__0
+  IODL_72 IODL__70 IOGTP IRET IRETN Q__0 GDLA TIEHIGH GDLA WE_74 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_76 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO1 BLTERM0_1 BLTERM0__1 BLTERM1_1 BLTERM1__1 BLTERM2_1 BLTERM2__1
+  BLTERM3_1 BLTERM3__1 BLTERM4_1 BLTERM4__1 BLTERM5_1 BLTERM5__1 BLTERM6_1
+  BLTERM6__1 BLTERM7_1 BLTERM7__1 BWEI_1 CE_WE CREN_1 TIEHIGH TIEHIGH TIEHIGH
+  DNI_1 FIOGTP GDL_1 GDLA TIEHIGH GDLA TIEHIGH GDLI_78 GDLI__80 GDL__1
+  IODL_84 IODL__82 IOGTP IRET IRETN Q__1 GDLA TIEHIGH GDLA WE_86 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_88 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO10 BLTERM0_10 BLTERM0__10 BLTERM1_10 BLTERM1__10 BLTERM2_10 BLTERM2__10
+  BLTERM3_10 BLTERM3__10 BLTERM4_10 BLTERM4__10 BLTERM5_10 BLTERM5__10
+  BLTERM6_10 BLTERM6__10 BLTERM7_10 BLTERM7__10 BWEI_10 CE_WE CREN_10 TIEHIGH
+  TIEHIGH TIEHIGH DNI_10 FIOGTP GDL_10 GDLA TIEHIGH GDLA TIEHIGH GDLI_6
+  GDLI__8 GDL__10 IODL_12 IODL__10 IOGTP IRET IRETN Q__10 GDLA TIEHIGH GDLA
+  WE_14 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_16 TIEHIGH TIEHIGH
+  TIEHIGH VSS VDD sram_AIO8
XLEFTIO11 BLTERM0_11 BLTERM0__11 BLTERM1_11 BLTERM1__11 BLTERM2_11 BLTERM2__11
+  BLTERM3_11 BLTERM3__11 BLTERM4_11 BLTERM4__11 BLTERM5_11 BLTERM5__11
+  BLTERM6_11 BLTERM6__11 BLTERM7_11 BLTERM7__11 BWEI_11 CE_WE CREN_11 TIEHIGH
+  TIEHIGH TIEHIGH DNI_11 FIOGTP GDL_11 GDLA TIEHIGH GDLA TIEHIGH GDLI_18
+  GDLI__20 GDL__11 IODL_24 IODL__22 IOGTP IRET IRETN Q__11 GDLA TIEHIGH GDLA
+  WE_26 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_28 TIEHIGH TIEHIGH
+  TIEHIGH VSS VDD sram_AIO8
XLEFTIO12 BLTERM0_12 BLTERM0__12 BLTERM1_12 BLTERM1__12 BLTERM2_12 BLTERM2__12
+  BLTERM3_12 BLTERM3__12 BLTERM4_12 BLTERM4__12 BLTERM5_12 BLTERM5__12
+  BLTERM6_12 BLTERM6__12 BLTERM7_12 BLTERM7__12 BWEI_12 CE_WE CREN_12 TIEHIGH
+  TIEHIGH TIEHIGH DNI_12 FIOGTP GDL_12 GDLA TIEHIGH GDLA TIEHIGH GDLI_30
+  GDLI__32 GDL__12 IODL_36 IODL__34 IOGTP IRET IRETN Q__12 GDLA TIEHIGH GDLA
+  WE_38 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_40 TIEHIGH TIEHIGH
+  TIEHIGH VSS VDD sram_AIO8
XLEFTIO13 BLTERM0_13 BLTERM0__13 BLTERM1_13 BLTERM1__13 BLTERM2_13 BLTERM2__13
+  BLTERM3_13 BLTERM3__13 BLTERM4_13 BLTERM4__13 BLTERM5_13 BLTERM5__13
+  BLTERM6_13 BLTERM6__13 BLTERM7_13 BLTERM7__13 BWEI_13 CE_WE CREN_13 TIEHIGH
+  TIEHIGH TIEHIGH DNI_13 FIOGTP GDL_13 GDLA TIEHIGH GDLA TIEHIGH GDLI_42
+  GDLI__44 GDL__13 IODL_48 IODL__46 IOGTP IRET IRETN Q__13 GDLA TIEHIGH GDLA
+  WE_50 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_52 TIEHIGH TIEHIGH
+  TIEHIGH VSS VDD sram_AIO8
XLEFTIO14 BLTERM0_14 BLTERM0__14 BLTERM1_14 BLTERM1__14 BLTERM2_14 BLTERM2__14
+  BLTERM3_14 BLTERM3__14 BLTERM4_14 BLTERM4__14 BLTERM5_14 BLTERM5__14
+  BLTERM6_14 BLTERM6__14 BLTERM7_14 BLTERM7__14 BWEI_14 CE_WE CREN_14 TIEHIGH
+  TIEHIGH TIEHIGH DNI_14 FIOGTP GDL_14 GDLA TIEHIGH GDLA TIEHIGH GDLI_54
+  GDLI__56 GDL__14 IODL_60 IODL__58 IOGTP IRET IRETN Q__14 GDLA TIEHIGH GDLA
+  WE_62 GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_64 TIEHIGH TIEHIGH
+  TIEHIGH VSS VDD sram_AIO8
XLEFTIO2 BLTERM0_2 BLTERM0__2 BLTERM1_2 BLTERM1__2 BLTERM2_2 BLTERM2__2
+  BLTERM3_2 BLTERM3__2 BLTERM4_2 BLTERM4__2 BLTERM5_2 BLTERM5__2 BLTERM6_2
+  BLTERM6__2 BLTERM7_2 BLTERM7__2 BWEI_2 CE_WE CREN_2 TIEHIGH TIEHIGH TIEHIGH
+  DNI_2 FIOGTP GDL_2 GDLA TIEHIGH GDLA TIEHIGH GDLI_90 GDLI__92 GDL__2
+  IODL_96 IODL__94 IOGTP IRET IRETN Q__2 GDLA TIEHIGH GDLA WE_98 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_100 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO3 BLTERM0_3 BLTERM0__3 BLTERM1_3 BLTERM1__3 BLTERM2_3 BLTERM2__3
+  BLTERM3_3 BLTERM3__3 BLTERM4_3 BLTERM4__3 BLTERM5_3 BLTERM5__3 BLTERM6_3
+  BLTERM6__3 BLTERM7_3 BLTERM7__3 BWEI_3 CE_WE CREN_3 TIEHIGH TIEHIGH TIEHIGH
+  DNI_3 FIOGTP GDL_3 GDLA TIEHIGH GDLA TIEHIGH GDLI_102 GDLI__104 GDL__3
+  IODL_108 IODL__106 IOGTP IRET IRETN Q__3 GDLA TIEHIGH GDLA WE_110 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_112 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO4 BLTERM0_4 BLTERM0__4 BLTERM1_4 BLTERM1__4 BLTERM2_4 BLTERM2__4
+  BLTERM3_4 BLTERM3__4 BLTERM4_4 BLTERM4__4 BLTERM5_4 BLTERM5__4 BLTERM6_4
+  BLTERM6__4 BLTERM7_4 BLTERM7__4 BWEI_4 CE_WE CREN_4 TIEHIGH TIEHIGH TIEHIGH
+  DNI_4 FIOGTP GDL_4 GDLA TIEHIGH GDLA TIEHIGH GDLI_114 GDLI__116 GDL__4
+  IODL_120 IODL__118 IOGTP IRET IRETN Q__4 GDLA TIEHIGH GDLA WE_122 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_124 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO5 BLTERM0_5 BLTERM0__5 BLTERM1_5 BLTERM1__5 BLTERM2_5 BLTERM2__5
+  BLTERM3_5 BLTERM3__5 BLTERM4_5 BLTERM4__5 BLTERM5_5 BLTERM5__5 BLTERM6_5
+  BLTERM6__5 BLTERM7_5 BLTERM7__5 BWEI_5 CE_WE CREN_5 TIEHIGH TIEHIGH TIEHIGH
+  DNI_5 FIOGTP GDL_5 GDLA TIEHIGH GDLA TIEHIGH GDLI_126 GDLI__128 GDL__5
+  IODL_132 IODL__130 IOGTP IRET IRETN Q__5 GDLA TIEHIGH GDLA WE_134 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_136 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO6 BLTERM0_6 BLTERM0__6 BLTERM1_6 BLTERM1__6 BLTERM2_6 BLTERM2__6
+  BLTERM3_6 BLTERM3__6 BLTERM4_6 BLTERM4__6 BLTERM5_6 BLTERM5__6 BLTERM6_6
+  BLTERM6__6 BLTERM7_6 BLTERM7__6 BWEI_6 CE_WE CREN_6 TIEHIGH TIEHIGH TIEHIGH
+  DNI_6 FIOGTP GDL_6 GDLA TIEHIGH GDLA TIEHIGH GDLI_138 GDLI__140 GDL__6
+  IODL_144 IODL__142 IOGTP IRET IRETN Q__6 GDLA TIEHIGH GDLA WE_146 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_148 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO7 BLTERM0_7 BLTERM0__7 BLTERM1_7 BLTERM1__7 BLTERM2_7 BLTERM2__7
+  BLTERM3_7 BLTERM3__7 BLTERM4_7 BLTERM4__7 BLTERM5_7 BLTERM5__7 BLTERM6_7
+  BLTERM6__7 BLTERM7_7 BLTERM7__7 BWEI_7 CE_WE CREN_7 TIEHIGH TIEHIGH TIEHIGH
+  DNI_7 FIOGTP GDL_7 GDLA TIEHIGH GDLA TIEHIGH GDLI_150 GDLI__152 GDL__7
+  IODL_156 IODL__154 IOGTP IRET IRETN Q__7 GDLA TIEHIGH GDLA WE_158 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_160 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO8 BLTERM0_8 BLTERM0__8 BLTERM1_8 BLTERM1__8 BLTERM2_8 BLTERM2__8
+  BLTERM3_8 BLTERM3__8 BLTERM4_8 BLTERM4__8 BLTERM5_8 BLTERM5__8 BLTERM6_8
+  BLTERM6__8 BLTERM7_8 BLTERM7__8 BWEI_8 CE_WE CREN_8 TIEHIGH TIEHIGH TIEHIGH
+  DNI_8 FIOGTP GDL_8 GDLA TIEHIGH GDLA TIEHIGH GDLI_162 GDLI__164 GDL__8
+  IODL_168 IODL__166 IOGTP IRET IRETN Q__8 GDLA TIEHIGH GDLA WE_170 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_172 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIO9 BLTERM0_9 BLTERM0__9 BLTERM1_9 BLTERM1__9 BLTERM2_9 BLTERM2__9
+  BLTERM3_9 BLTERM3__9 BLTERM4_9 BLTERM4__9 BLTERM5_9 BLTERM5__9 BLTERM6_9
+  BLTERM6__9 BLTERM7_9 BLTERM7__9 BWEI_9 CE_WE CREN_9 TIEHIGH TIEHIGH TIEHIGH
+  DNI_9 FIOGTP GDL_9 GDLA TIEHIGH GDLA TIEHIGH GDLI_174 GDLI__176 GDL__9
+  IODL_180 IODL__178 IOGTP IRET IRETN Q__9 GDLA TIEHIGH GDLA WE_182 GDLA GDLA
+  GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_184 TIEHIGH TIEHIGH TIEHIGH VSS VDD
+  sram_AIO8
XLEFTIOEDGE16 CE_WE TIEHIGH FIOGTP GDLA TIEHIGH IOGTP IRETN IRET VSS TIEHIGH
+  TIELOW GDLA GDLA YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH VSS VDD sram_AIO8EDGE
XLEFTIOEXT15 BLTERM0_15 BLTERM0__15 BLTERM1_15 BLTERM1__15 BLTERM2_15
+  BLTERM2__15 BLTERM3_15 BLTERM3__15 BLTERM4_15 BLTERM4__15 BLTERM5_15
+  BLTERM5__15 BLTERM6_15 BLTERM6__15 BLTERM7_15 BLTERM7__15 BWEI_15 CE_WE
+  CREN_15 TIEHIGH TIEHIGH TIEHIGH DNI_15 FIOGTP GDL_15 GDLA TIEHIGH GDLA
+  TIEHIGH GDLI GDLI_ GDL__15 IODL IODL_ IOGTP IRET IRETN Q__15 GDLA TIEHIGH
+  GDLA WE GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN TIEHIGH TIEHIGH
+  TIEHIGH VSS VDD sram_AIO8
.ENDS sram_AIO8RL16
****
.SUBCKT sram_ABR32IO8 A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N
+  A13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BLTERM0_0 BLTERM0_1
+  BLTERM0_2 BLTERM0_3 BLTERM0_4 BLTERM0_5 BLTERM0_6 BLTERM0_7 BLTERM0_8
+  BLTERM0_9 BLTERM0_10 BLTERM0_11 BLTERM0_12 BLTERM0_13 BLTERM0_14 BLTERM0_15
+  BLTERM0_16 BLTERM0_17 BLTERM0_18 BLTERM0_19 BLTERM0_20 BLTERM0_21
+  BLTERM0_22 BLTERM0_23 BLTERM0_24 BLTERM0_25 BLTERM0_26 BLTERM0_27
+  BLTERM0_28 BLTERM0_29 BLTERM0_30 BLTERM0_31 BLTERM0__0 BLTERM0__1
+  BLTERM0__2 BLTERM0__3 BLTERM0__4 BLTERM0__5 BLTERM0__6 BLTERM0__7
+  BLTERM0__8 BLTERM0__9 BLTERM0__10 BLTERM0__11 BLTERM0__12 BLTERM0__13
+  BLTERM0__14 BLTERM0__15 BLTERM0__16 BLTERM0__17 BLTERM0__18 BLTERM0__19
+  BLTERM0__20 BLTERM0__21 BLTERM0__22 BLTERM0__23 BLTERM0__24 BLTERM0__25
+  BLTERM0__26 BLTERM0__27 BLTERM0__28 BLTERM0__29 BLTERM0__30 BLTERM0__31
+  BLTERM1_0 BLTERM1_1 BLTERM1_2 BLTERM1_3 BLTERM1_4 BLTERM1_5 BLTERM1_6
+  BLTERM1_7 BLTERM1_8 BLTERM1_9 BLTERM1_10 BLTERM1_11 BLTERM1_12 BLTERM1_13
+  BLTERM1_14 BLTERM1_15 BLTERM1_16 BLTERM1_17 BLTERM1_18 BLTERM1_19
+  BLTERM1_20 BLTERM1_21 BLTERM1_22 BLTERM1_23 BLTERM1_24 BLTERM1_25
+  BLTERM1_26 BLTERM1_27 BLTERM1_28 BLTERM1_29 BLTERM1_30 BLTERM1_31
+  BLTERM1__0 BLTERM1__1 BLTERM1__2 BLTERM1__3 BLTERM1__4 BLTERM1__5
+  BLTERM1__6 BLTERM1__7 BLTERM1__8 BLTERM1__9 BLTERM1__10 BLTERM1__11
+  BLTERM1__12 BLTERM1__13 BLTERM1__14 BLTERM1__15 BLTERM1__16 BLTERM1__17
+  BLTERM1__18 BLTERM1__19 BLTERM1__20 BLTERM1__21 BLTERM1__22 BLTERM1__23
+  BLTERM1__24 BLTERM1__25 BLTERM1__26 BLTERM1__27 BLTERM1__28 BLTERM1__29
+  BLTERM1__30 BLTERM1__31 BLTERM2_0 BLTERM2_1 BLTERM2_2 BLTERM2_3 BLTERM2_4
+  BLTERM2_5 BLTERM2_6 BLTERM2_7 BLTERM2_8 BLTERM2_9 BLTERM2_10 BLTERM2_11
+  BLTERM2_12 BLTERM2_13 BLTERM2_14 BLTERM2_15 BLTERM2_16 BLTERM2_17
+  BLTERM2_18 BLTERM2_19 BLTERM2_20 BLTERM2_21 BLTERM2_22 BLTERM2_23
+  BLTERM2_24 BLTERM2_25 BLTERM2_26 BLTERM2_27 BLTERM2_28 BLTERM2_29
+  BLTERM2_30 BLTERM2_31 BLTERM2__0 BLTERM2__1 BLTERM2__2 BLTERM2__3
+  BLTERM2__4 BLTERM2__5 BLTERM2__6 BLTERM2__7 BLTERM2__8 BLTERM2__9
+  BLTERM2__10 BLTERM2__11 BLTERM2__12 BLTERM2__13 BLTERM2__14 BLTERM2__15
+  BLTERM2__16 BLTERM2__17 BLTERM2__18 BLTERM2__19 BLTERM2__20 BLTERM2__21
+  BLTERM2__22 BLTERM2__23 BLTERM2__24 BLTERM2__25 BLTERM2__26 BLTERM2__27
+  BLTERM2__28 BLTERM2__29 BLTERM2__30 BLTERM2__31 BLTERM3_0 BLTERM3_1
+  BLTERM3_2 BLTERM3_3 BLTERM3_4 BLTERM3_5 BLTERM3_6 BLTERM3_7 BLTERM3_8
+  BLTERM3_9 BLTERM3_10 BLTERM3_11 BLTERM3_12 BLTERM3_13 BLTERM3_14 BLTERM3_15
+  BLTERM3_16 BLTERM3_17 BLTERM3_18 BLTERM3_19 BLTERM3_20 BLTERM3_21
+  BLTERM3_22 BLTERM3_23 BLTERM3_24 BLTERM3_25 BLTERM3_26 BLTERM3_27
+  BLTERM3_28 BLTERM3_29 BLTERM3_30 BLTERM3_31 BLTERM3__0 BLTERM3__1
+  BLTERM3__2 BLTERM3__3 BLTERM3__4 BLTERM3__5 BLTERM3__6 BLTERM3__7
+  BLTERM3__8 BLTERM3__9 BLTERM3__10 BLTERM3__11 BLTERM3__12 BLTERM3__13
+  BLTERM3__14 BLTERM3__15 BLTERM3__16 BLTERM3__17 BLTERM3__18 BLTERM3__19
+  BLTERM3__20 BLTERM3__21 BLTERM3__22 BLTERM3__23 BLTERM3__24 BLTERM3__25
+  BLTERM3__26 BLTERM3__27 BLTERM3__28 BLTERM3__29 BLTERM3__30 BLTERM3__31
+  BLTERM4_0 BLTERM4_1 BLTERM4_2 BLTERM4_3 BLTERM4_4 BLTERM4_5 BLTERM4_6
+  BLTERM4_7 BLTERM4_8 BLTERM4_9 BLTERM4_10 BLTERM4_11 BLTERM4_12 BLTERM4_13
+  BLTERM4_14 BLTERM4_15 BLTERM4_16 BLTERM4_17 BLTERM4_18 BLTERM4_19
+  BLTERM4_20 BLTERM4_21 BLTERM4_22 BLTERM4_23 BLTERM4_24 BLTERM4_25
+  BLTERM4_26 BLTERM4_27 BLTERM4_28 BLTERM4_29 BLTERM4_30 BLTERM4_31
+  BLTERM4__0 BLTERM4__1 BLTERM4__2 BLTERM4__3 BLTERM4__4 BLTERM4__5
+  BLTERM4__6 BLTERM4__7 BLTERM4__8 BLTERM4__9 BLTERM4__10 BLTERM4__11
+  BLTERM4__12 BLTERM4__13 BLTERM4__14 BLTERM4__15 BLTERM4__16 BLTERM4__17
+  BLTERM4__18 BLTERM4__19 BLTERM4__20 BLTERM4__21 BLTERM4__22 BLTERM4__23
+  BLTERM4__24 BLTERM4__25 BLTERM4__26 BLTERM4__27 BLTERM4__28 BLTERM4__29
+  BLTERM4__30 BLTERM4__31 BLTERM5_0 BLTERM5_1 BLTERM5_2 BLTERM5_3 BLTERM5_4
+  BLTERM5_5 BLTERM5_6 BLTERM5_7 BLTERM5_8 BLTERM5_9 BLTERM5_10 BLTERM5_11
+  BLTERM5_12 BLTERM5_13 BLTERM5_14 BLTERM5_15 BLTERM5_16 BLTERM5_17
+  BLTERM5_18 BLTERM5_19 BLTERM5_20 BLTERM5_21 BLTERM5_22 BLTERM5_23
+  BLTERM5_24 BLTERM5_25 BLTERM5_26 BLTERM5_27 BLTERM5_28 BLTERM5_29
+  BLTERM5_30 BLTERM5_31 BLTERM5__0 BLTERM5__1 BLTERM5__2 BLTERM5__3
+  BLTERM5__4 BLTERM5__5 BLTERM5__6 BLTERM5__7 BLTERM5__8 BLTERM5__9
+  BLTERM5__10 BLTERM5__11 BLTERM5__12 BLTERM5__13 BLTERM5__14 BLTERM5__15
+  BLTERM5__16 BLTERM5__17 BLTERM5__18 BLTERM5__19 BLTERM5__20 BLTERM5__21
+  BLTERM5__22 BLTERM5__23 BLTERM5__24 BLTERM5__25 BLTERM5__26 BLTERM5__27
+  BLTERM5__28 BLTERM5__29 BLTERM5__30 BLTERM5__31 BLTERM6_0 BLTERM6_1
+  BLTERM6_2 BLTERM6_3 BLTERM6_4 BLTERM6_5 BLTERM6_6 BLTERM6_7 BLTERM6_8
+  BLTERM6_9 BLTERM6_10 BLTERM6_11 BLTERM6_12 BLTERM6_13 BLTERM6_14 BLTERM6_15
+  BLTERM6_16 BLTERM6_17 BLTERM6_18 BLTERM6_19 BLTERM6_20 BLTERM6_21
+  BLTERM6_22 BLTERM6_23 BLTERM6_24 BLTERM6_25 BLTERM6_26 BLTERM6_27
+  BLTERM6_28 BLTERM6_29 BLTERM6_30 BLTERM6_31 BLTERM6__0 BLTERM6__1
+  BLTERM6__2 BLTERM6__3 BLTERM6__4 BLTERM6__5 BLTERM6__6 BLTERM6__7
+  BLTERM6__8 BLTERM6__9 BLTERM6__10 BLTERM6__11 BLTERM6__12 BLTERM6__13
+  BLTERM6__14 BLTERM6__15 BLTERM6__16 BLTERM6__17 BLTERM6__18 BLTERM6__19
+  BLTERM6__20 BLTERM6__21 BLTERM6__22 BLTERM6__23 BLTERM6__24 BLTERM6__25
+  BLTERM6__26 BLTERM6__27 BLTERM6__28 BLTERM6__29 BLTERM6__30 BLTERM6__31
+  BLTERM7_0 BLTERM7_1 BLTERM7_2 BLTERM7_3 BLTERM7_4 BLTERM7_5 BLTERM7_6
+  BLTERM7_7 BLTERM7_8 BLTERM7_9 BLTERM7_10 BLTERM7_11 BLTERM7_12 BLTERM7_13
+  BLTERM7_14 BLTERM7_15 BLTERM7_16 BLTERM7_17 BLTERM7_18 BLTERM7_19
+  BLTERM7_20 BLTERM7_21 BLTERM7_22 BLTERM7_23 BLTERM7_24 BLTERM7_25
+  BLTERM7_26 BLTERM7_27 BLTERM7_28 BLTERM7_29 BLTERM7_30 BLTERM7_31
+  BLTERM7__0 BLTERM7__1 BLTERM7__2 BLTERM7__3 BLTERM7__4 BLTERM7__5
+  BLTERM7__6 BLTERM7__7 BLTERM7__8 BLTERM7__9 BLTERM7__10 BLTERM7__11
+  BLTERM7__12 BLTERM7__13 BLTERM7__14 BLTERM7__15 BLTERM7__16 BLTERM7__17
+  BLTERM7__18 BLTERM7__19 BLTERM7__20 BLTERM7__21 BLTERM7__22 BLTERM7__23
+  BLTERM7__24 BLTERM7__25 BLTERM7__26 BLTERM7__27 BLTERM7__28 BLTERM7__29
+  BLTERM7__30 BLTERM7__31 BS0N BS1N BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15
+  BWEI_16 BWEI_17 BWEI_18 BWEI_19 BWEI_20 BWEI_21 BWEI_22 BWEI_23 BWEI_24
+  BWEI_25 BWEI_26 BWEI_27 BWEI_28 BWEI_29 BWEI_30 BWEI_31 CEI CLK CREN_0
+  CREN_1 CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7 CREN_8 CREN_9 CREN_10
+  CREN_11 CREN_12 CREN_13 CREN_14 CREN_15 CREN_16 CREN_17 CREN_18 CREN_19
+  CREN_20 CREN_21 CREN_22 CREN_23 CREN_24 CREN_25 CREN_26 CREN_27 CREN_28
+  CREN_29 CREN_30 CREN_31 DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7
+  DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 DNI_16 DNI_17 DNI_18
+  DNI_19 DNI_20 DNI_21 DNI_22 DNI_23 DNI_24 DNI_25 DNI_26 DNI_27 DNI_28
+  DNI_29 DNI_30 DNI_31 EMA0 EMA1 EMA2 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26
+  GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4
+  GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14
+  GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21 GDL__22 GDL__23
+  GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30 GDL__31 GTP GTPDET
+  GTPDST IRET IRETN LGWEN MATCH0 MATCH1 MATCH2 MATCH3 MBL MGDLET MGDLST MGTPS
+  MWLLATE PRDT PWBT Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10
+  Q__11 Q__12 Q__13 Q__14 Q__15 Q__16 Q__17 Q__18 Q__19 Q__20 Q__21 Q__22
+  Q__23 Q__24 Q__25 Q__26 Q__27 Q__28 Q__29 Q__30 Q__31 RDT RETN RRENDD RXP0
+  RXP1 RXP2 RXP3 STOV T0L_TERM TIEHIGH_0 TIEHIGH_1 TIELOW_0 TIELOW_1 TIELOW_2
+  TL0_TERM WBTDD WEI VSS VDD
** sram_ABR32IO8: 6087 flat devices **
XBOTCTRL A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N A13N AX0N AX1N
+  AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0N BS1N CEI CE_WE CLK TIEHIGH_0
+  TIEHIGH_1 EMA0 EMA1 EMA2 FIOGTP_8 FIOGTP TIELOW_2 TIEHIGH_1 WE_TERM_0
+  TIEHIGH_0 GTP GTPDET GTPDST IOGTP_10 IOGTP LGWEN MATCH0 MATCH1 MATCH2
+  MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE VSS VSS PRDT PWBT RDT RETN IRETN
+  IRET RRENDD RXP0 RXP1 RXP2 RXP3 STOV T0L_TERM TIEHIGH_1 TIEHIGH_0 TIELOW_2
+  WE_TERM_0 TL0_TERM WBTDD WEI WE_TERM_0 TIELOW_2 YP1_0 YP1_1 YP1_2 YP1_3
+  TIEHIGH_0 TIEHIGH_1 VSS VDD sram_ABCTRL32M8
XLEFTIOROW BLTERM0_15 BLTERM0_14 BLTERM0_13 BLTERM0_12 BLTERM0_11 BLTERM0_10
+  BLTERM0_9 BLTERM0_8 BLTERM0_7 BLTERM0_6 BLTERM0_5 BLTERM0_4 BLTERM0_3
+  BLTERM0_2 BLTERM0_1 BLTERM0_0 BLTERM0__15 BLTERM0__14 BLTERM0__13
+  BLTERM0__12 BLTERM0__11 BLTERM0__10 BLTERM0__9 BLTERM0__8 BLTERM0__7
+  BLTERM0__6 BLTERM0__5 BLTERM0__4 BLTERM0__3 BLTERM0__2 BLTERM0__1
+  BLTERM0__0 BLTERM1_15 BLTERM1_14 BLTERM1_13 BLTERM1_12 BLTERM1_11
+  BLTERM1_10 BLTERM1_9 BLTERM1_8 BLTERM1_7 BLTERM1_6 BLTERM1_5 BLTERM1_4
+  BLTERM1_3 BLTERM1_2 BLTERM1_1 BLTERM1_0 BLTERM1__15 BLTERM1__14 BLTERM1__13
+  BLTERM1__12 BLTERM1__11 BLTERM1__10 BLTERM1__9 BLTERM1__8 BLTERM1__7
+  BLTERM1__6 BLTERM1__5 BLTERM1__4 BLTERM1__3 BLTERM1__2 BLTERM1__1
+  BLTERM1__0 BLTERM2_15 BLTERM2_14 BLTERM2_13 BLTERM2_12 BLTERM2_11
+  BLTERM2_10 BLTERM2_9 BLTERM2_8 BLTERM2_7 BLTERM2_6 BLTERM2_5 BLTERM2_4
+  BLTERM2_3 BLTERM2_2 BLTERM2_1 BLTERM2_0 BLTERM2__15 BLTERM2__14 BLTERM2__13
+  BLTERM2__12 BLTERM2__11 BLTERM2__10 BLTERM2__9 BLTERM2__8 BLTERM2__7
+  BLTERM2__6 BLTERM2__5 BLTERM2__4 BLTERM2__3 BLTERM2__2 BLTERM2__1
+  BLTERM2__0 BLTERM3_15 BLTERM3_14 BLTERM3_13 BLTERM3_12 BLTERM3_11
+  BLTERM3_10 BLTERM3_9 BLTERM3_8 BLTERM3_7 BLTERM3_6 BLTERM3_5 BLTERM3_4
+  BLTERM3_3 BLTERM3_2 BLTERM3_1 BLTERM3_0 BLTERM3__15 BLTERM3__14 BLTERM3__13
+  BLTERM3__12 BLTERM3__11 BLTERM3__10 BLTERM3__9 BLTERM3__8 BLTERM3__7
+  BLTERM3__6 BLTERM3__5 BLTERM3__4 BLTERM3__3 BLTERM3__2 BLTERM3__1
+  BLTERM3__0 BLTERM4_15 BLTERM4_14 BLTERM4_13 BLTERM4_12 BLTERM4_11
+  BLTERM4_10 BLTERM4_9 BLTERM4_8 BLTERM4_7 BLTERM4_6 BLTERM4_5 BLTERM4_4
+  BLTERM4_3 BLTERM4_2 BLTERM4_1 BLTERM4_0 BLTERM4__15 BLTERM4__14 BLTERM4__13
+  BLTERM4__12 BLTERM4__11 BLTERM4__10 BLTERM4__9 BLTERM4__8 BLTERM4__7
+  BLTERM4__6 BLTERM4__5 BLTERM4__4 BLTERM4__3 BLTERM4__2 BLTERM4__1
+  BLTERM4__0 BLTERM5_15 BLTERM5_14 BLTERM5_13 BLTERM5_12 BLTERM5_11
+  BLTERM5_10 BLTERM5_9 BLTERM5_8 BLTERM5_7 BLTERM5_6 BLTERM5_5 BLTERM5_4
+  BLTERM5_3 BLTERM5_2 BLTERM5_1 BLTERM5_0 BLTERM5__15 BLTERM5__14 BLTERM5__13
+  BLTERM5__12 BLTERM5__11 BLTERM5__10 BLTERM5__9 BLTERM5__8 BLTERM5__7
+  BLTERM5__6 BLTERM5__5 BLTERM5__4 BLTERM5__3 BLTERM5__2 BLTERM5__1
+  BLTERM5__0 BLTERM6_15 BLTERM6_14 BLTERM6_13 BLTERM6_12 BLTERM6_11
+  BLTERM6_10 BLTERM6_9 BLTERM6_8 BLTERM6_7 BLTERM6_6 BLTERM6_5 BLTERM6_4
+  BLTERM6_3 BLTERM6_2 BLTERM6_1 BLTERM6_0 BLTERM6__15 BLTERM6__14 BLTERM6__13
+  BLTERM6__12 BLTERM6__11 BLTERM6__10 BLTERM6__9 BLTERM6__8 BLTERM6__7
+  BLTERM6__6 BLTERM6__5 BLTERM6__4 BLTERM6__3 BLTERM6__2 BLTERM6__1
+  BLTERM6__0 BLTERM7_15 BLTERM7_14 BLTERM7_13 BLTERM7_12 BLTERM7_11
+  BLTERM7_10 BLTERM7_9 BLTERM7_8 BLTERM7_7 BLTERM7_6 BLTERM7_5 BLTERM7_4
+  BLTERM7_3 BLTERM7_2 BLTERM7_1 BLTERM7_0 BLTERM7__15 BLTERM7__14 BLTERM7__13
+  BLTERM7__12 BLTERM7__11 BLTERM7__10 BLTERM7__9 BLTERM7__8 BLTERM7__7
+  BLTERM7__6 BLTERM7__5 BLTERM7__4 BLTERM7__3 BLTERM7__2 BLTERM7__1
+  BLTERM7__0 BWEI_15 BWEI_14 BWEI_13 BWEI_12 BWEI_11 BWEI_10 BWEI_9 BWEI_8
+  BWEI_7 BWEI_6 BWEI_5 BWEI_4 BWEI_3 BWEI_2 BWEI_1 BWEI_0 CE_WE CREN_15
+  CREN_14 CREN_13 CREN_12 CREN_11 CREN_10 CREN_9 CREN_8 CREN_7 CREN_6 CREN_5
+  CREN_4 CREN_3 CREN_2 CREN_1 CREN_0 DNI_15 DNI_14 DNI_13 DNI_12 DNI_11
+  DNI_10 DNI_9 DNI_8 DNI_7 DNI_6 DNI_5 DNI_4 DNI_3 DNI_2 DNI_1 DNI_0 FIOGTP_8
+  WE_TERM_0 GDL_15 GDL_14 GDL_13 GDL_12 GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6
+  GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0 GDL__15 GDL__14 GDL__13 GDL__12 GDL__11
+  GDL__10 GDL__9 GDL__8 GDL__7 GDL__6 GDL__5 GDL__4 GDL__3 GDL__2 GDL__1
+  GDL__0 IOGTP_10 IRET IRETN Q__15 Q__14 Q__13 Q__12 Q__11 Q__10 Q__9 Q__8
+  Q__7 Q__6 Q__5 Q__4 Q__3 Q__2 Q__1 Q__0 TIEHIGH_0 TIELOW_0 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD sram_AIO8RL16
XRIGHTIOROW BLTERM0_16 BLTERM0_17 BLTERM0_18 BLTERM0_19 BLTERM0_20 BLTERM0_21
+  BLTERM0_22 BLTERM0_23 BLTERM0_24 BLTERM0_25 BLTERM0_26 BLTERM0_27
+  BLTERM0_28 BLTERM0_29 BLTERM0_30 BLTERM0_31 BLTERM0__16 BLTERM0__17
+  BLTERM0__18 BLTERM0__19 BLTERM0__20 BLTERM0__21 BLTERM0__22 BLTERM0__23
+  BLTERM0__24 BLTERM0__25 BLTERM0__26 BLTERM0__27 BLTERM0__28 BLTERM0__29
+  BLTERM0__30 BLTERM0__31 BLTERM1_16 BLTERM1_17 BLTERM1_18 BLTERM1_19
+  BLTERM1_20 BLTERM1_21 BLTERM1_22 BLTERM1_23 BLTERM1_24 BLTERM1_25
+  BLTERM1_26 BLTERM1_27 BLTERM1_28 BLTERM1_29 BLTERM1_30 BLTERM1_31
+  BLTERM1__16 BLTERM1__17 BLTERM1__18 BLTERM1__19 BLTERM1__20 BLTERM1__21
+  BLTERM1__22 BLTERM1__23 BLTERM1__24 BLTERM1__25 BLTERM1__26 BLTERM1__27
+  BLTERM1__28 BLTERM1__29 BLTERM1__30 BLTERM1__31 BLTERM2_16 BLTERM2_17
+  BLTERM2_18 BLTERM2_19 BLTERM2_20 BLTERM2_21 BLTERM2_22 BLTERM2_23
+  BLTERM2_24 BLTERM2_25 BLTERM2_26 BLTERM2_27 BLTERM2_28 BLTERM2_29
+  BLTERM2_30 BLTERM2_31 BLTERM2__16 BLTERM2__17 BLTERM2__18 BLTERM2__19
+  BLTERM2__20 BLTERM2__21 BLTERM2__22 BLTERM2__23 BLTERM2__24 BLTERM2__25
+  BLTERM2__26 BLTERM2__27 BLTERM2__28 BLTERM2__29 BLTERM2__30 BLTERM2__31
+  BLTERM3_16 BLTERM3_17 BLTERM3_18 BLTERM3_19 BLTERM3_20 BLTERM3_21
+  BLTERM3_22 BLTERM3_23 BLTERM3_24 BLTERM3_25 BLTERM3_26 BLTERM3_27
+  BLTERM3_28 BLTERM3_29 BLTERM3_30 BLTERM3_31 BLTERM3__16 BLTERM3__17
+  BLTERM3__18 BLTERM3__19 BLTERM3__20 BLTERM3__21 BLTERM3__22 BLTERM3__23
+  BLTERM3__24 BLTERM3__25 BLTERM3__26 BLTERM3__27 BLTERM3__28 BLTERM3__29
+  BLTERM3__30 BLTERM3__31 BLTERM4_16 BLTERM4_17 BLTERM4_18 BLTERM4_19
+  BLTERM4_20 BLTERM4_21 BLTERM4_22 BLTERM4_23 BLTERM4_24 BLTERM4_25
+  BLTERM4_26 BLTERM4_27 BLTERM4_28 BLTERM4_29 BLTERM4_30 BLTERM4_31
+  BLTERM4__16 BLTERM4__17 BLTERM4__18 BLTERM4__19 BLTERM4__20 BLTERM4__21
+  BLTERM4__22 BLTERM4__23 BLTERM4__24 BLTERM4__25 BLTERM4__26 BLTERM4__27
+  BLTERM4__28 BLTERM4__29 BLTERM4__30 BLTERM4__31 BLTERM5_16 BLTERM5_17
+  BLTERM5_18 BLTERM5_19 BLTERM5_20 BLTERM5_21 BLTERM5_22 BLTERM5_23
+  BLTERM5_24 BLTERM5_25 BLTERM5_26 BLTERM5_27 BLTERM5_28 BLTERM5_29
+  BLTERM5_30 BLTERM5_31 BLTERM5__16 BLTERM5__17 BLTERM5__18 BLTERM5__19
+  BLTERM5__20 BLTERM5__21 BLTERM5__22 BLTERM5__23 BLTERM5__24 BLTERM5__25
+  BLTERM5__26 BLTERM5__27 BLTERM5__28 BLTERM5__29 BLTERM5__30 BLTERM5__31
+  BLTERM6_16 BLTERM6_17 BLTERM6_18 BLTERM6_19 BLTERM6_20 BLTERM6_21
+  BLTERM6_22 BLTERM6_23 BLTERM6_24 BLTERM6_25 BLTERM6_26 BLTERM6_27
+  BLTERM6_28 BLTERM6_29 BLTERM6_30 BLTERM6_31 BLTERM6__16 BLTERM6__17
+  BLTERM6__18 BLTERM6__19 BLTERM6__20 BLTERM6__21 BLTERM6__22 BLTERM6__23
+  BLTERM6__24 BLTERM6__25 BLTERM6__26 BLTERM6__27 BLTERM6__28 BLTERM6__29
+  BLTERM6__30 BLTERM6__31 BLTERM7_16 BLTERM7_17 BLTERM7_18 BLTERM7_19
+  BLTERM7_20 BLTERM7_21 BLTERM7_22 BLTERM7_23 BLTERM7_24 BLTERM7_25
+  BLTERM7_26 BLTERM7_27 BLTERM7_28 BLTERM7_29 BLTERM7_30 BLTERM7_31
+  BLTERM7__16 BLTERM7__17 BLTERM7__18 BLTERM7__19 BLTERM7__20 BLTERM7__21
+  BLTERM7__22 BLTERM7__23 BLTERM7__24 BLTERM7__25 BLTERM7__26 BLTERM7__27
+  BLTERM7__28 BLTERM7__29 BLTERM7__30 BLTERM7__31 BWEI_16 BWEI_17 BWEI_18
+  BWEI_19 BWEI_20 BWEI_21 BWEI_22 BWEI_23 BWEI_24 BWEI_25 BWEI_26 BWEI_27
+  BWEI_28 BWEI_29 BWEI_30 BWEI_31 CE_WE CREN_16 CREN_17 CREN_18 CREN_19
+  CREN_20 CREN_21 CREN_22 CREN_23 CREN_24 CREN_25 CREN_26 CREN_27 CREN_28
+  CREN_29 CREN_30 CREN_31 DNI_16 DNI_17 DNI_18 DNI_19 DNI_20 DNI_21 DNI_22
+  DNI_23 DNI_24 DNI_25 DNI_26 DNI_27 DNI_28 DNI_29 DNI_30 DNI_31 FIOGTP
+  TIELOW_2 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL__16 GDL__17 GDL__18
+  GDL__19 GDL__20 GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27
+  GDL__28 GDL__29 GDL__30 GDL__31 IOGTP IRET IRETN Q__16 Q__17 Q__18 Q__19
+  Q__20 Q__21 Q__22 Q__23 Q__24 Q__25 Q__26 Q__27 Q__28 Q__29 Q__30 Q__31
+  TIEHIGH_1 TIELOW_1 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD sram_AIO8RR16
.ENDS sram_ABR32IO8
****
.SUBCKT sram_ACD8 BL0 BL0_ BL1 BL1_ BL2 BL2_ BL3 BL3_ BL4 BL4_ BL5 BL5_ BL6
+  BL6_ BL7 BL7_ BTP DR DRPREN DR_ DW DW_ GDL GDL_ YP0N YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N YP1N YP2N YP3N YP4N YP5N YP6N YP7N VSS
+  VDD
** sram_ACD8: 100 flat devices **
M0 BL0 YPPASS0 DR VDD PCH W=0.66U L=0.06U M=1 $name=/tblpass/P00
M1 BL1_ YPPASS1 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P14/P00
M10 BL4 YPPASS4 DR VDD PCH W=0.66U L=0.06U M=1 $name=/P46/P00
M11 BL5_ YPPASS5 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P52/P00
M12 BL6 YPPASS6 DR VDD PCH W=0.66U L=0.06U M=1 $name=/P55/P00
M13 BL6_ YPPASS6 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P60/P00
M14 BL7 YPPASS7 DR VDD PCH W=0.66U L=0.06U M=1 $name=/P62/P00
M15 BL7_ YPPASS7 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P61/P00
M16 VDD NET284 PRE0 VDD PCH W=0.88U L=0.06U M=1 $name=/P73/P00
M17 VDD NET287 PRE3 VDD PCH W=0.88U L=0.06U M=1 $name=/P75/P00
M18 BL2_ PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P20/P00
M19 BL7_ PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P58/P00
M2 BL0_ YPPASS0 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P53/P00
M20 BL3_ PRE0 BL3 VDD PCH W=0.66U L=0.06U M=1 $name=/P28/P00
M21 BL0 PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/tpre/P00
M22 BL0_ PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P0/P00
M23 BL0_ PRE0 BL0 VDD PCH W=0.66U L=0.06U M=1 $name=/P1/P00
M24 BL1 PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P13/P00
M25 BL1_ PRE0 BL1 VDD PCH W=0.66U L=0.06U M=1 $name=/P12/P00
M26 BL3_ PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P27/P00
M27 BL3 PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P29/P00
M28 BL2_ PRE0 BL2 VDD PCH W=0.66U L=0.06U M=1 $name=/P19/P00
M29 BL2 PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P18/P00
M3 BL1 YPPASS1 DR VDD PCH W=0.66U L=0.06U M=1 $name=/P10/P00
M30 BL5 PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P35/P00
M31 BL4 PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P41/P00
M32 BL5_ PRE3 BL5 VDD PCH W=0.66U L=0.06U M=1 $name=/P39/P00
M33 BL5_ PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P44/P00
M34 BL4_ PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P47/P00
M35 BL6 PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P51/P00
M36 BL6_ PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P49/P00
M37 BL6_ PRE3 BL6 VDD PCH W=0.66U L=0.06U M=1 $name=/P50/P00
M38 BL7_ PRE3 BL7 VDD PCH W=0.66U L=0.06U M=1 $name=/P59/P00
M39 BL7 PRE3 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P63/P00
M4 BL2_ YPPASS2 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P17/P00
M40 BL1_ PRE0 VDD VDD PCH W=0.66U L=0.06U M=1 $name=/P11/P00
M41 BL4_ PRE3 BL4 VDD PCH W=0.66U L=0.06U M=1 $name=/P48/P00
M42 VDD DRPREN DR_ VDD PCH W=0.34U L=0.06U M=1 $name=/P9/P00
M43 VDD DRPREN DR VDD PCH W=0.34U L=0.06U M=1 $name=/P8/P00
M44 VDD DW_ DR VDD PCH W=0.34U L=0.06U M=1 $name=/P7/P00
M45 VDD DW DR_ VDD PCH W=0.34U L=0.06U M=1 $name=/P5/P00
M46 BL5_ YNPASS5 DW_ VSS NCH W=1U L=0.06U M=1 $name=/N10/N00
M47 BL0 YNPASS0 DW VSS NCH W=1U L=0.06U M=1 $name=/P3/N00
M48 BL1 YNPASS1 DW VSS NCH W=1U L=0.06U M=1 $name=/N2/N00
M49 BL0_ YNPASS0 DW_ VSS NCH W=1U L=0.06U M=1 $name=/P4/N00
M5 BL3 YPPASS3 DR VDD PCH W=0.66U L=0.06U M=1 $name=/P26/P00
M50 BL3_ YNPASS3 DW_ VSS NCH W=1U L=0.06U M=1 $name=/N9/N00
M51 BL2 YNPASS2 DW VSS NCH W=1U L=0.06U M=1 $name=/N5/N00
M52 BL2_ YNPASS2 DW_ VSS NCH W=1U L=0.06U M=1 $name=/N4/N00
M53 BL3 YNPASS3 DW VSS NCH W=1U L=0.06U M=1 $name=/N8/N00
M54 BL5 YNPASS5 DW VSS NCH W=1U L=0.06U M=1 $name=/N12/N00
M55 BL4 YNPASS4 DW VSS NCH W=1U L=0.06U M=1 $name=/N11/N00
M56 BL6_ YNPASS6 DW_ VSS NCH W=1U L=0.06U M=1 $name=/N15/N00
M57 BL7_ YNPASS7 DW_ VSS NCH W=1U L=0.06U M=1 $name=/N18/N00
M58 BL4_ YNPASS4 DW_ VSS NCH W=1U L=0.06U M=1 $name=/N17/N00
M59 BL6 YNPASS6 DW VSS NCH W=1U L=0.06U M=1 $name=/N21/N00
M6 BL3_ YPPASS3 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P30/P00
M60 BL7 YNPASS7 DW VSS NCH W=1U L=0.06U M=1 $name=/N19/N00
M61 BL1_ YNPASS1 DW_ VSS NCH W=1U L=0.06U M=1 $name=/N3/N00
M62 YNPASS0 YP0N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I12/N00
M63 VDD YP0N YNPASS0 VDD PCH W=0.4U L=0.06U M=1 $name=/I12/P00
M64 YPPASS0 YNPASS0 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M65 VDD YNPASS0 YPPASS0 VDD PCH W=0.25U L=0.06U M=1 $name=/I1/P00
M66 YNPASS1 YP1N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I20/N00
M67 VDD YP1N YNPASS1 VDD PCH W=0.4U L=0.06U M=1 $name=/I20/P00
M68 YPPASS1 YNPASS1 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I23/N00
M69 VDD YNPASS1 YPPASS1 VDD PCH W=0.25U L=0.06U M=1 $name=/I23/P00
M7 BL2 YPPASS2 DR VDD PCH W=0.66U L=0.06U M=1 $name=/P21/P00
M70 YNPASS2 YP2N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I24/N00
M71 VDD YP2N YNPASS2 VDD PCH W=0.4U L=0.06U M=1 $name=/I24/P00
M72 YPPASS2 YNPASS2 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I25/N00
M73 VDD YNPASS2 YPPASS2 VDD PCH W=0.25U L=0.06U M=1 $name=/I25/P00
M74 YNPASS3 YP3N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I26/N00
M75 VDD YP3N YNPASS3 VDD PCH W=0.4U L=0.06U M=1 $name=/I26/P00
M76 YPPASS3 YNPASS3 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I27/N00
M77 VDD YNPASS3 YPPASS3 VDD PCH W=0.25U L=0.06U M=1 $name=/I27/P00
M78 YNPASS4 YP4N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I28/N00
M79 VDD YP4N YNPASS4 VDD PCH W=0.4U L=0.06U M=1 $name=/I28/P00
M8 BL5 YPPASS5 DR VDD PCH W=0.66U L=0.06U M=1 $name=/P38/P00
M80 YPPASS4 YNPASS4 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I29/N00
M81 VDD YNPASS4 YPPASS4 VDD PCH W=0.25U L=0.06U M=1 $name=/I29/P00
M82 YPPASS5 YNPASS5 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I30/N00
M83 VDD YNPASS5 YPPASS5 VDD PCH W=0.25U L=0.06U M=1 $name=/I30/P00
M84 YNPASS5 YP5N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I33/N00
M85 VDD YP5N YNPASS5 VDD PCH W=0.4U L=0.06U M=1 $name=/I33/P00
M86 YPPASS7 YNPASS7 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I34/N00
M87 VDD YNPASS7 YPPASS7 VDD PCH W=0.25U L=0.06U M=1 $name=/I34/P00
M88 YNPASS7 YP7N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I35/N00
M89 VDD YP7N YNPASS7 VDD PCH W=0.4U L=0.06U M=1 $name=/I35/P00
M9 BL4_ YPPASS4 DR_ VDD PCH W=0.66U L=0.06U M=1 $name=/P42/P00
M90 YNPASS6 YP6N VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I36/N00
M91 VDD YP6N YNPASS6 VDD PCH W=0.4U L=0.06U M=1 $name=/I36/P00
M92 YPPASS6 YNPASS6 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I39/N00
M93 VDD YNPASS6 YPPASS6 VDD PCH W=0.25U L=0.06U M=1 $name=/I39/P00
M94 NET284 BTP VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I3/N00
M95 VDD BTP NET284 VDD PCH W=0.2U L=0.06U M=1 $name=/I3/P00
M96 NET287 BTP VSS VSS NCH W=0.2U L=0.06U M=1 $name=/I93/N00
M97 VDD BTP NET287 VDD PCH W=0.2U L=0.06U M=1 $name=/I93/P00
M98 PRE0 NET284 VSS VSS NCH_HVT W=0.44U L=0.06U M=1 $name=/N38/N00
M99 PRE3 NET287 VSS VSS NCH_HVT W=0.44U L=0.06U M=1 $name=/N40/N00
.ENDS sram_ACD8
****
.SUBCKT sram_ACDEDGE BTP DRPREN PG_TERM TIELOW YP0_0 YP0_1 YP0_2 YP0_3 YP0_4
+  YP0_5 YP0_6 YP0_7 VSS VDD
** sram_ACDEDGE: 4 flat devices **
M0 VDD NET22 NET22 VDD PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M1 VDD TIELOW NET22 VDD PCH W=0.18U L=0.06U M=1 $name=/P0/P00
M2 TIELOW TIELOW VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M3 TIELOW NET22 VSS VSS NCH W=0.18U L=0.06U M=1 $name=/N2/N00
.ENDS sram_ACDEDGE
****
.SUBCKT sram_ACDROWRB032T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0__0 BL0__1 BL0__2
+  BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12
+  BL0__13 BL0__14 BL0__15 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7
+  BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1__0 BL1__1 BL1__2
+  BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12
+  BL1__13 BL1__14 BL1__15 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7
+  BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2__0 BL2__1 BL2__2
+  BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11 BL2__12
+  BL2__13 BL2__14 BL2__15 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7
+  BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3__0 BL3__1 BL3__2
+  BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BL3__10 BL3__11 BL3__12
+  BL3__13 BL3__14 BL3__15 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7
+  BL4_8 BL4_9 BL4_10 BL4_11 BL4_12 BL4_13 BL4_14 BL4_15 BL4__0 BL4__1 BL4__2
+  BL4__3 BL4__4 BL4__5 BL4__6 BL4__7 BL4__8 BL4__9 BL4__10 BL4__11 BL4__12
+  BL4__13 BL4__14 BL4__15 BL5_0 BL5_1 BL5_2 BL5_3 BL5_4 BL5_5 BL5_6 BL5_7
+  BL5_8 BL5_9 BL5_10 BL5_11 BL5_12 BL5_13 BL5_14 BL5_15 BL5__0 BL5__1 BL5__2
+  BL5__3 BL5__4 BL5__5 BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11 BL5__12
+  BL5__13 BL5__14 BL5__15 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6 BL6_7
+  BL6_8 BL6_9 BL6_10 BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6__0 BL6__1 BL6__2
+  BL6__3 BL6__4 BL6__5 BL6__6 BL6__7 BL6__8 BL6__9 BL6__10 BL6__11 BL6__12
+  BL6__13 BL6__14 BL6__15 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6 BL7_7
+  BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7__0 BL7__1 BL7__2
+  BL7__3 BL7__4 BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11 BL7__12
+  BL7__13 BL7__14 BL7__15 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7
+  DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2 DR__3 DR__4
+  DR__5 DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13 DR__14 DR__15
+  DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13
+  DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9
+  DW__10 DW__11 DW__12 DW__13 DW__14 DW__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 TIELOW YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD
** sram_ACDROWRB032T: 1604 flat devices **
XCD81 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BL4_0 BL4__0 BL5_0
+  BL5__0 BL6_0 BL6__0 BL7_0 BL7__0 BTP DR_0 DRPREN DR__0 DW_0 DW__0 GDL_0
+  GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD810 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BL4_9 BL4__9 BL5_9
+  BL5__9 BL6_9 BL6__9 BL7_9 BL7__9 BTP DR_9 DRPREN DR__9 DW_9 DW__9 GDL_9
+  GDL__9 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD811 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BL4_10
+  BL4__10 BL5_10 BL5__10 BL6_10 BL6__10 BL7_10 BL7__10 BTP DR_10 DRPREN
+  DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD812 BL0_11 BL0__11 BL1_11 BL1__11 BL2_11 BL2__11 BL3_11 BL3__11 BL4_11
+  BL4__11 BL5_11 BL5__11 BL6_11 BL6__11 BL7_11 BL7__11 BTP DR_11 DRPREN
+  DR__11 DW_11 DW__11 GDL_11 GDL__11 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD813 BL0_12 BL0__12 BL1_12 BL1__12 BL2_12 BL2__12 BL3_12 BL3__12 BL4_12
+  BL4__12 BL5_12 BL5__12 BL6_12 BL6__12 BL7_12 BL7__12 BTP DR_12 DRPREN
+  DR__12 DW_12 DW__12 GDL_12 GDL__12 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD814 BL0_13 BL0__13 BL1_13 BL1__13 BL2_13 BL2__13 BL3_13 BL3__13 BL4_13
+  BL4__13 BL5_13 BL5__13 BL6_13 BL6__13 BL7_13 BL7__13 BTP DR_13 DRPREN
+  DR__13 DW_13 DW__13 GDL_13 GDL__13 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD815 BL0_14 BL0__14 BL1_14 BL1__14 BL2_14 BL2__14 BL3_14 BL3__14 BL4_14
+  BL4__14 BL5_14 BL5__14 BL6_14 BL6__14 BL7_14 BL7__14 BTP DR_14 DRPREN
+  DR__14 DW_14 DW__14 GDL_14 GDL__14 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD816 BL0_15 BL0__15 BL1_15 BL1__15 BL2_15 BL2__15 BL3_15 BL3__15 BL4_15
+  BL4__15 BL5_15 BL5__15 BL6_15 BL6__15 BL7_15 BL7__15 BTP DR_15 DRPREN
+  DR__15 DW_15 DW__15 GDL_15 GDL__15 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD82 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BL4_1 BL4__1 BL5_1
+  BL5__1 BL6_1 BL6__1 BL7_1 BL7__1 BTP DR_1 DRPREN DR__1 DW_1 DW__1 GDL_1
+  GDL__1 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD83 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BL4_2 BL4__2 BL5_2
+  BL5__2 BL6_2 BL6__2 BL7_2 BL7__2 BTP DR_2 DRPREN DR__2 DW_2 DW__2 GDL_2
+  GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD84 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BL4_3 BL4__3 BL5_3
+  BL5__3 BL6_3 BL6__3 BL7_3 BL7__3 BTP DR_3 DRPREN DR__3 DW_3 DW__3 GDL_3
+  GDL__3 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD85 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BL4_4 BL4__4 BL5_4
+  BL5__4 BL6_4 BL6__4 BL7_4 BL7__4 BTP DR_4 DRPREN DR__4 DW_4 DW__4 GDL_4
+  GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD86 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BL4_5 BL4__5 BL5_5
+  BL5__5 BL6_5 BL6__5 BL7_5 BL7__5 BTP DR_5 DRPREN DR__5 DW_5 DW__5 GDL_5
+  GDL__5 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD87 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BL4_6 BL4__6 BL5_6
+  BL5__6 BL6_6 BL6__6 BL7_6 BL7__6 BTP DR_6 DRPREN DR__6 DW_6 DW__6 GDL_6
+  GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD88 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BL4_7 BL4__7 BL5_7
+  BL5__7 BL6_7 BL6__7 BL7_7 BL7__7 BTP DR_7 DRPREN DR__7 DW_7 DW__7 GDL_7
+  GDL__7 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD89 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BL4_8 BL4__8 BL5_8
+  BL5__8 BL6_8 BL6__8 BL7_8 BL7__8 BTP DR_8 DRPREN DR__8 DW_8 DW__8 GDL_8
+  GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XI128 BTP DRPREN VSS TIELOW YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACDEDGE
.ENDS sram_ACDROWRB032T
****
.SUBCKT sram_ACDROWRT032T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0__0 BL0__1 BL0__2
+  BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12
+  BL0__13 BL0__14 BL0__15 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7
+  BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1__0 BL1__1 BL1__2
+  BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12
+  BL1__13 BL1__14 BL1__15 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7
+  BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2__0 BL2__1 BL2__2
+  BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11 BL2__12
+  BL2__13 BL2__14 BL2__15 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7
+  BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3__0 BL3__1 BL3__2
+  BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BL3__10 BL3__11 BL3__12
+  BL3__13 BL3__14 BL3__15 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7
+  BL4_8 BL4_9 BL4_10 BL4_11 BL4_12 BL4_13 BL4_14 BL4_15 BL4__0 BL4__1 BL4__2
+  BL4__3 BL4__4 BL4__5 BL4__6 BL4__7 BL4__8 BL4__9 BL4__10 BL4__11 BL4__12
+  BL4__13 BL4__14 BL4__15 BL5_0 BL5_1 BL5_2 BL5_3 BL5_4 BL5_5 BL5_6 BL5_7
+  BL5_8 BL5_9 BL5_10 BL5_11 BL5_12 BL5_13 BL5_14 BL5_15 BL5__0 BL5__1 BL5__2
+  BL5__3 BL5__4 BL5__5 BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11 BL5__12
+  BL5__13 BL5__14 BL5__15 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6 BL6_7
+  BL6_8 BL6_9 BL6_10 BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6__0 BL6__1 BL6__2
+  BL6__3 BL6__4 BL6__5 BL6__6 BL6__7 BL6__8 BL6__9 BL6__10 BL6__11 BL6__12
+  BL6__13 BL6__14 BL6__15 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6 BL7_7
+  BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7__0 BL7__1 BL7__2
+  BL7__3 BL7__4 BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11 BL7__12
+  BL7__13 BL7__14 BL7__15 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7
+  DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2 DR__3 DR__4
+  DR__5 DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13 DR__14 DR__15
+  DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13
+  DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9
+  DW__10 DW__11 DW__12 DW__13 DW__14 DW__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 TIELOW YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD
** sram_ACDROWRT032T: 1604 flat devices **
XCD81 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BL4_0 BL4__0 BL5_0
+  BL5__0 BL6_0 BL6__0 BL7_0 BL7__0 BTP DR_0 DRPREN DR__0 DW_0 DW__0 GDL_0
+  GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD810 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BL4_9 BL4__9 BL5_9
+  BL5__9 BL6_9 BL6__9 BL7_9 BL7__9 BTP DR_9 DRPREN DR__9 DW_9 DW__9 GDL_9
+  GDL__9 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD811 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BL4_10
+  BL4__10 BL5_10 BL5__10 BL6_10 BL6__10 BL7_10 BL7__10 BTP DR_10 DRPREN
+  DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD812 BL0_11 BL0__11 BL1_11 BL1__11 BL2_11 BL2__11 BL3_11 BL3__11 BL4_11
+  BL4__11 BL5_11 BL5__11 BL6_11 BL6__11 BL7_11 BL7__11 BTP DR_11 DRPREN
+  DR__11 DW_11 DW__11 GDL_11 GDL__11 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD813 BL0_12 BL0__12 BL1_12 BL1__12 BL2_12 BL2__12 BL3_12 BL3__12 BL4_12
+  BL4__12 BL5_12 BL5__12 BL6_12 BL6__12 BL7_12 BL7__12 BTP DR_12 DRPREN
+  DR__12 DW_12 DW__12 GDL_12 GDL__12 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD814 BL0_13 BL0__13 BL1_13 BL1__13 BL2_13 BL2__13 BL3_13 BL3__13 BL4_13
+  BL4__13 BL5_13 BL5__13 BL6_13 BL6__13 BL7_13 BL7__13 BTP DR_13 DRPREN
+  DR__13 DW_13 DW__13 GDL_13 GDL__13 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD815 BL0_14 BL0__14 BL1_14 BL1__14 BL2_14 BL2__14 BL3_14 BL3__14 BL4_14
+  BL4__14 BL5_14 BL5__14 BL6_14 BL6__14 BL7_14 BL7__14 BTP DR_14 DRPREN
+  DR__14 DW_14 DW__14 GDL_14 GDL__14 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD816 BL0_15 BL0__15 BL1_15 BL1__15 BL2_15 BL2__15 BL3_15 BL3__15 BL4_15
+  BL4__15 BL5_15 BL5__15 BL6_15 BL6__15 BL7_15 BL7__15 BTP DR_15 DRPREN
+  DR__15 DW_15 DW__15 GDL_15 GDL__15 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD82 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BL4_1 BL4__1 BL5_1
+  BL5__1 BL6_1 BL6__1 BL7_1 BL7__1 BTP DR_1 DRPREN DR__1 DW_1 DW__1 GDL_1
+  GDL__1 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD83 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BL4_2 BL4__2 BL5_2
+  BL5__2 BL6_2 BL6__2 BL7_2 BL7__2 BTP DR_2 DRPREN DR__2 DW_2 DW__2 GDL_2
+  GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD84 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BL4_3 BL4__3 BL5_3
+  BL5__3 BL6_3 BL6__3 BL7_3 BL7__3 BTP DR_3 DRPREN DR__3 DW_3 DW__3 GDL_3
+  GDL__3 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD85 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BL4_4 BL4__4 BL5_4
+  BL5__4 BL6_4 BL6__4 BL7_4 BL7__4 BTP DR_4 DRPREN DR__4 DW_4 DW__4 GDL_4
+  GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD86 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BL4_5 BL4__5 BL5_5
+  BL5__5 BL6_5 BL6__5 BL7_5 BL7__5 BTP DR_5 DRPREN DR__5 DW_5 DW__5 GDL_5
+  GDL__5 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD87 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BL4_6 BL4__6 BL5_6
+  BL5__6 BL6_6 BL6__6 BL7_6 BL7__6 BTP DR_6 DRPREN DR__6 DW_6 DW__6 GDL_6
+  GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD88 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BL4_7 BL4__7 BL5_7
+  BL5__7 BL6_7 BL6__7 BL7_7 BL7__7 BTP DR_7 DRPREN DR__7 DW_7 DW__7 GDL_7
+  GDL__7 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD89 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BL4_8 BL4__8 BL5_8
+  BL5__8 BL6_8 BL6__8 BL7_8 BL7__8 BTP DR_8 DRPREN DR__8 DW_8 DW__8 GDL_8
+  GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XI128 BTP DRPREN VSS TIELOW YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACDEDGE
.ENDS sram_ACDROWRT032T
****
.SUBCKT sram_AXP ATRACK0 ATRACK0B ATRACK0T ATRACK1 ATRACK1B ATRACK1T ATRACK2
+  ATRACK2B ATRACK2T ATRACK3 ATRACK3B ATRACK3T ATRACK4 ATRACK4B ATRACK4T
+  ATRACK5 ATRACK5B ATRACK5T AX5N AX5NIN BTPB BTPBN BTPCDB BTPCDT BTPSA BTPSAN
+  BTPT BTPTN BTPWN BTPWNN DRPRENB DRPRENT PDRPREB PDRPRET PG_TERM RET SAEN
+  SAENN TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0 XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_
+  XP4 XP4_ XP5 XP5_ YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T
+  YP0_4B YP0_4T YP0_5B YP0_5T YP0_6B YP0_6T YP0_7B YP0_7T VSS VDD
** sram_AXP: 143 flat devices **
M0 VDD A2_ NET468 VDD PCH W=1.1U L=0.06U M=1 $name=/txppnand/P00
M1 VDD A4 NET438 VDD PCH W=1.1U L=0.06U M=1 $name=/P9/P00
M10 VDD AI0_ NET498 VDD PCH W=1.1U L=0.06U M=1 $name=/P28/P00
M100 VDD NET595 A4_ VDD PCH W=1.12U L=0.06U M=1 $name=/I61/P00
M101 XP3_ NET468 VSS VSS NCH W=2U L=0.06U M=1 $name=/I60/N00
M102 VDD NET468 XP3_ VDD PCH W=4U L=0.06U M=1 $name=/I60/P00
M103 A4 ATRACK4 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I59/N00
M104 VDD ATRACK4 A4 VDD PCH W=1.12U L=0.06U M=1 $name=/I59/P00
M105 XP4_ NET484 VSS VSS NCH W=2U L=0.06U M=1 $name=/I58/N00
M106 VDD NET484 XP4_ VDD PCH W=4U L=0.06U M=1 $name=/I58/P00
M107 XP4 NET387 VSS VSS NCH W=2U L=0.06U M=1 $name=/I57/N00
M108 VDD NET387 XP4 VDD PCH W=4U L=0.06U M=1 $name=/I57/P00
M109 A5_ NET599 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I56/N00
M11 VDD A1 NET510 VDD PCH W=1.1U L=0.06U M=1 $name=/P25/P00
M110 VDD NET599 A5_ VDD PCH W=1.12U L=0.06U M=1 $name=/I56/P00
M111 A5 AX5NIN VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I55/N00
M112 VDD AX5NIN A5 VDD PCH W=1.12U L=0.06U M=1 $name=/I55/P00
M113 XP5_ NET526 VSS VSS NCH W=2U L=0.06U M=1 $name=/I54/N00
M114 VDD NET526 XP5_ VDD PCH W=4U L=0.06U M=1 $name=/I54/P00
M115 BTPCDB NET540 VSS VSS NCH W=5U L=0.06U M=1 $name=/I49/N00
M116 VDD NET540 BTPCDB VDD PCH W=10.02U L=0.06U M=1 $name=/I49/P00
M117 BTPB BTPBN VSS VSS NCH W=5U L=0.06U M=1 $name=/I47/N00
M118 VDD BTPBN BTPB VDD PCH W=10.02U L=0.06U M=1 $name=/I47/P00
M119 NET595 ATRACK4 VSS VSS NCH W=0.28U L=0.06U M=1 $name=/I45/N00
M12 VDD AI0 NET402 VDD PCH W=1.1U L=0.06U M=1 $name=/P24/P00
M120 VDD ATRACK4 NET595 VDD PCH W=0.38U L=0.06U M=1 $name=/I45/P00
M121 SAEN SAENN VSS VSS NCH W=5U L=0.06U M=1 $name=/I44/N00
M122 VDD SAENN SAEN VDD PCH W=10.02U L=0.06U M=1 $name=/I44/P00
M123 NET599 AX5NIN VSS VSS NCH W=0.28U L=0.06U M=1 $name=/I42/N00
M124 VDD AX5NIN NET599 VDD PCH W=0.38U L=0.06U M=1 $name=/I42/P00
M125 BTPT BTPTN VSS VSS NCH W=5U L=0.06U M=1 $name=/I40/N00
M126 VDD BTPTN BTPT VDD PCH W=10.02U L=0.06U M=1 $name=/I40/P00
M127 XP5 NET438 VSS VSS NCH W=2U L=0.06U M=1 $name=/I39/N00
M128 VDD NET438 XP5 VDD PCH W=4U L=0.06U M=1 $name=/I39/P00
M129 XP0_ NET498 VSS VSS NCH W=2U L=0.06U M=1 $name=/I35/N00
M13 VDD A1 NET402 VDD PCH W=1.1U L=0.06U M=1 $name=/P23/P00
M130 VDD NET498 XP0_ VDD PCH W=4U L=0.06U M=1 $name=/I35/P00
M131 NET607 ATRACK2 VSS VSS NCH W=0.28U L=0.06U M=1 $name=/I34/N00
M132 VDD ATRACK2 NET607 VDD PCH W=0.38U L=0.06U M=1 $name=/I34/P00
M133 XP0 NET390 VSS VSS NCH W=2U L=0.06U M=1 $name=/I33/N00
M134 VDD NET390 XP0 VDD PCH W=4U L=0.06U M=1 $name=/I33/P00
M135 XP1 NET402 VSS VSS NCH W=2U L=0.06U M=1 $name=/I31/N00
M136 VDD NET402 XP1 VDD PCH W=4U L=0.06U M=1 $name=/I31/P00
M137 NET562 ATRACK1 VSS VSS NCH W=0.28U L=0.06U M=1 $name=/I30/N00
M138 VDD ATRACK1 NET562 VDD PCH W=0.38U L=0.06U M=1 $name=/I30/P00
M139 NET558 ATRACK0 VSS VSS NCH W=0.28U L=0.06U M=1 $name=/I29/N00
M14 VDD AI0_ NET510 VDD PCH W=1.1U L=0.06U M=1 $name=/P22/P00
M140 VDD ATRACK0 NET558 VDD PCH W=0.38U L=0.06U M=1 $name=/I29/P00
M141 XP2_ NET522 VSS VSS NCH W=2U L=0.06U M=1 $name=/I28/N00
M142 VDD NET522 XP2_ VDD PCH W=4U L=0.06U M=1 $name=/I28/P00
M15 VDD A4 NET387 VDD PCH W=1.1U L=0.06U M=1 $name=/P2/P00
M16 VDD A3_ NET522 VDD PCH W=1.1U L=0.06U M=1 $name=/P19/P00
M17 VDD A2 NET417 VDD PCH W=1.1U L=0.06U M=1 $name=/P18/P00
M18 VDD A3_ NET417 VDD PCH W=1.1U L=0.06U M=1 $name=/P17/P00
M19 VDD A2_ NET522 VDD PCH W=1.1U L=0.06U M=1 $name=/P16/P00
M2 NET484 A5_ VDD VDD PCH W=1.1U L=0.06U M=1 $name=/P8/P00
M20 NET526 A5 VDD VDD PCH W=1.1U L=0.06U M=1 $name=/P15/P00
M21 NET526 A4_ VDD VDD PCH W=1.1U L=0.06U M=1 $name=/P14/P00
M22 VDD A3 NET468 VDD PCH W=1.1U L=0.06U M=1 $name=/P13/P00
M23 VDD A2 NET435 VDD PCH W=1.1U L=0.06U M=1 $name=/P12/P00
M24 VDD A3 NET435 VDD PCH W=1.1U L=0.06U M=1 $name=/P11/P00
M25 VDD A5 NET438 VDD PCH W=1.1U L=0.06U M=1 $name=/P10/P00
M26 VDD TIELOWB NET444 VDD PCH W=4.8U L=0.06U M=1 $name=/P1/P00
M27 VDD NET444 NET444 VDD PCH W=0.15U L=0.06U M=1 $name=/P0/P00
M28 VSS RET DRPRENT VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N24/N00
M29 VSS RET DRPRENB VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N25/N00
M3 VDD NET372 NET372 VDD PCH W=0.15U L=0.06U M=1 $name=/P57/P00
M30 VSS RET BTPT VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N9/N00
M31 VSS RET BTPCDT VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N6/N00
M32 VSS RET BTPCDB VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N20/N00
M33 VSS RET BTPB VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N19/N00
M34 VSS RET BTPSA VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M35 NET472 A2_ NET468 VSS NCH W=1.72U L=0.06U M=1 $name=/txpnnand/N00
M36 NET472 A2 NET435 VSS NCH W=1.72U L=0.06U M=1 $name=/N8/N00
M37 NET472 A3 VSS VSS NCH W=1.72U L=0.06U M=1 $name=/N7/N00
M38 TIELOWT TIELOWT VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N60/N00
M39 TIELOWT NET372 VSS VSS NCH W=3U L=0.06U M=1 $name=/N59/N00
M4 VDD TIELOWT NET372 VDD PCH W=4.8U L=0.06U M=1 $name=/P56/P00
M40 NET484 A4_ NET490 VSS NCH W=1.72U L=0.06U M=1 $name=/N5/N00
M41 NET490 A5_ VSS VSS NCH W=1.72U L=0.06U M=1 $name=/N4/N00
M42 NET490 A4 NET387 VSS NCH W=1.72U L=0.06U M=1 $name=/N3/N00
M43 NET493 AI0 NET390 VSS NCH W=1.72U L=0.06U M=1 $name=/N23/N00
M44 NET493 A1_ VSS VSS NCH W=1.72U L=0.06U M=1 $name=/N22/N00
M45 NET493 AI0_ NET498 VSS NCH W=1.72U L=0.06U M=1 $name=/N21/N00
M46 TIELOWB TIELOWB VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N2/N00
M47 NET505 AI0 NET402 VSS NCH W=1.72U L=0.06U M=1 $name=/N18/N00
M48 NET505 A1 VSS VSS NCH W=1.72U L=0.06U M=1 $name=/N17/N00
M49 NET505 AI0_ NET510 VSS NCH W=1.72U L=0.06U M=1 $name=/N16/N00
M5 NET484 A4_ VDD VDD PCH W=1.1U L=0.06U M=1 $name=/P4/P00
M50 TIELOWB NET444 VSS VSS NCH W=3U L=0.06U M=1 $name=/N14/N00
M51 NET517 A2 NET417 VSS NCH W=1.72U L=0.06U M=1 $name=/N13/N00
M52 NET517 A3_ VSS VSS NCH W=1.72U L=0.06U M=1 $name=/N12/N00
M53 NET517 A2_ NET522 VSS NCH W=1.72U L=0.06U M=1 $name=/N11/N00
M54 NET526 A4_ NET532 VSS NCH W=1.72U L=0.06U M=1 $name=/N10/N00
M55 NET532 A5 VSS VSS NCH W=1.72U L=0.06U M=1 $name=/N1/N00
M56 NET532 A4 NET438 VSS NCH W=1.72U L=0.06U M=1 $name=/N0/N00
M57 DRPRENT NET534 VSS VSS NCH W=5U L=0.06U M=1 $name=/I1/N00
M58 VDD NET534 DRPRENT VDD PCH W=10.02U L=0.06U M=1 $name=/I1/P00
M59 NET534 PDRPRET VSS VSS NCH W=3.6U L=0.06U M=1 $name=/I4/N00
M6 VDD A1_ NET498 VDD PCH W=1.1U L=0.06U M=1 $name=/P31/P00
M60 VDD PDRPRET NET534 VDD PCH W=5U L=0.06U M=1 $name=/I4/P00
M61 NET540 PDRPREB VSS VSS NCH W=3.6U L=0.06U M=1 $name=/I5/N00
M62 VDD PDRPREB NET540 VDD PCH W=5U L=0.06U M=1 $name=/I5/P00
M63 DRPRENB NET540 VSS VSS NCH W=5U L=0.06U M=1 $name=/I6/N00
M64 VDD NET540 DRPRENB VDD PCH W=10.02U L=0.06U M=1 $name=/I6/P00
M65 NET541 ATRACK3 VSS VSS NCH W=0.28U L=0.06U M=1 $name=/tinvain/N00
M66 VDD ATRACK3 NET541 VDD PCH W=0.38U L=0.06U M=1 $name=/tinvain/P00
M67 A3_ NET541 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/tinvaidd/N00
M68 VDD NET541 A3_ VDD PCH W=1.12U L=0.06U M=1 $name=/tinvaidd/P00
M69 A3 ATRACK3 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/tinvai/N00
M7 VDD AI0 NET390 VDD PCH W=1.1U L=0.06U M=1 $name=/P30/P00
M70 VDD ATRACK3 A3 VDD PCH W=1.12U L=0.06U M=1 $name=/tinvai/P00
M71 BTPWN BTPWNN VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpwnl/N00
M72 VDD BTPWNN BTPWN VDD PCH W=10.02U L=0.06U M=1 $name=/tbtpwnl/P00
M73 BTPSA BTPSAN VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpsal/N00
M74 VDD BTPSAN BTPSA VDD PCH W=10.02U L=0.06U M=1 $name=/tbtpsal/P00
M75 BTPCDT NET534 VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpcdl/N00
M76 VDD NET534 BTPCDT VDD PCH W=10.02U L=0.06U M=1 $name=/tbtpcdl/P00
M77 XP3 NET435 VSS VSS NCH W=2U L=0.06U M=1 $name=/apdrv/N00
M78 VDD NET435 XP3 VDD PCH W=4U L=0.06U M=1 $name=/apdrv/P00
M79 TIEHIGHT TIELOWT VSS VSS NCH W=3U L=0.06U M=1 $name=/I96/N00
M8 VDD A5_ NET387 VDD PCH W=1.1U L=0.06U M=1 $name=/P3/P00
M80 VDD TIELOWT TIEHIGHT VDD PCH W=4.8U L=0.06U M=1 $name=/I96/P00
M81 AI0_ NET558 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I81/N00
M82 VDD NET558 AI0_ VDD PCH W=1.12U L=0.06U M=1 $name=/I81/P00
M83 AI0 ATRACK0 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I80/N00
M84 VDD ATRACK0 AI0 VDD PCH W=1.12U L=0.06U M=1 $name=/I80/P00
M85 A1_ NET562 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I79/N00
M86 VDD NET562 A1_ VDD PCH W=1.12U L=0.06U M=1 $name=/I79/P00
M87 A1 ATRACK1 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I78/N00
M88 VDD ATRACK1 A1 VDD PCH W=1.12U L=0.06U M=1 $name=/I78/P00
M89 A2_ NET607 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I77/N00
M9 VDD A1_ NET390 VDD PCH W=1.1U L=0.06U M=1 $name=/P29/P00
M90 VDD NET607 A2_ VDD PCH W=1.12U L=0.06U M=1 $name=/I77/P00
M91 A2 ATRACK2 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I76/N00
M92 VDD ATRACK2 A2 VDD PCH W=1.12U L=0.06U M=1 $name=/I76/P00
M93 TIEHIGHB TIELOWB VSS VSS NCH W=3U L=0.06U M=1 $name=/I64/N00
M94 VDD TIELOWB TIEHIGHB VDD PCH W=4.8U L=0.06U M=1 $name=/I64/P00
M95 XP1_ NET510 VSS VSS NCH W=2U L=0.06U M=1 $name=/I63/N00
M96 VDD NET510 XP1_ VDD PCH W=4U L=0.06U M=1 $name=/I63/P00
M97 XP2 NET417 VSS VSS NCH W=2U L=0.06U M=1 $name=/I62/N00
M98 VDD NET417 XP2 VDD PCH W=4U L=0.06U M=1 $name=/I62/P00
M99 A4_ NET595 VSS VSS NCH W=0.82U L=0.06U M=1 $name=/I61/N00
.ENDS sram_AXP
****
.SUBCKT sram_AAPY AX5N AY0N AY0NB AY0NT AY1N AY1NB AY1NT AY2N AY2NB AY2NT BSBN
+  BSTN BTPB2_TERM BTPB3_TERM BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1 BTPWDT0
+  BTPWDT1 PBTPSA PBTPSAB PBTPSAT PBTPWN PDRPREB PDRPRET PSAEN RET RRBTPB
+  RRBTPT RXP0 RXP1 RXP2 RXP3 YP0_0NB YP0_0NT YP0_1NB YP0_1NT YP0_2NB YP0_2NT
+  YP0_3NB YP0_3NT YP0_4NB YP0_4NT YP0_5NB YP0_5NT YP0_6NB YP0_6NT YP0_7NB
+  YP0_7NT VSS VDD
** sram_AAPY: 236 flat devices **
M0 BST AIND7T_ YP7T VDD PCH W=2U L=0.06U M=1 $name=/tppass/P00
M1 YP6B AIND6B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P7/P00
M10 BST AIND4T_ YP4T VDD PCH W=2U L=0.06U M=1 $name=/P39/P00
M100 VDD AI1 AIND6B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I169/P10
M101 VDD AI0_ AIND6B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I169/P00
M102 HNET342 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I168/N02
M103 HNET343 AI1 HNET342 VSS NCH W=0.8U L=0.06U M=1 $name=/I168/N01
M104 AIND7B_ AI0 HNET343 VSS NCH W=0.8U L=0.06U M=1 $name=/I168/N00
M105 VDD AI2 AIND7B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I168/P20
M106 VDD AI1 AIND7B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I168/P10
M107 VDD AI0 AIND7B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I168/P00
M108 HNET349 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I163/N02
M109 HNET350 AI1_ HNET349 VSS NCH W=0.8U L=0.06U M=1 $name=/I163/N01
M11 BST AIND6T_ YP6T VDD PCH W=2U L=0.06U M=1 $name=/P38/P00
M110 AIND4B_ AI0_ HNET350 VSS NCH W=0.8U L=0.06U M=1 $name=/I163/N00
M111 VDD AI2 AIND4B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I163/P20
M112 VDD AI1_ AIND4B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I163/P10
M113 VDD AI0_ AIND4B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I163/P00
M114 HNET356 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I162/N02
M115 HNET357 AI1_ HNET356 VSS NCH W=0.8U L=0.06U M=1 $name=/I162/N01
M116 AIND5B_ AI0 HNET357 VSS NCH W=0.8U L=0.06U M=1 $name=/I162/N00
M117 VDD AI2 AIND5B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I162/P20
M118 VDD AI1_ AIND5B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I162/P10
M119 VDD AI0 AIND5B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I162/P00
M12 YP2B AIND2B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P3/P00
M120 HNET363 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I152/N02
M121 HNET364 AI1 HNET363 VSS NCH W=0.8U L=0.06U M=1 $name=/I152/N01
M122 AIND2B_ AI0_ HNET364 VSS NCH W=0.8U L=0.06U M=1 $name=/I152/N00
M123 VDD AI2_ AIND2B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I152/P20
M124 VDD AI1 AIND2B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I152/P10
M125 VDD AI0_ AIND2B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I152/P00
M126 HNET370 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I151/N02
M127 HNET371 AI1 HNET370 VSS NCH W=0.8U L=0.06U M=1 $name=/I151/N01
M128 AIND3B_ AI0 HNET371 VSS NCH W=0.8U L=0.06U M=1 $name=/I151/N00
M129 VDD AI2_ AIND3B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I151/P20
M13 YP3B AIND3B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P2/P00
M130 VDD AI1 AIND3B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I151/P10
M131 VDD AI0 AIND3B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I151/P00
M132 HNET377 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I150/N02
M133 HNET378 AI1_ HNET377 VSS NCH W=0.8U L=0.06U M=1 $name=/I150/N01
M134 AIND1B_ AI0 HNET378 VSS NCH W=0.8U L=0.06U M=1 $name=/I150/N00
M135 VDD AI2_ AIND1B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I150/P20
M136 VDD AI1_ AIND1B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I150/P10
M137 VDD AI0 AIND1B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I150/P00
M138 HNET384 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I149/N02
M139 HNET385 AI1_ HNET384 VSS NCH W=0.8U L=0.06U M=1 $name=/I149/N01
M14 YP0B AIND0B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P1/P00
M140 AIND0B_ AI0_ HNET385 VSS NCH W=0.8U L=0.06U M=1 $name=/I149/N00
M141 VDD AI2_ AIND0B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I149/P20
M142 VDD AI1_ AIND0B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I149/P10
M143 VDD AI0_ AIND0B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I149/P00
M144 NET490 AY2N VSS VSS NCH W=0.3U L=0.06U M=1 $name=/taininv/N00
M145 VDD AY2N NET490 VDD PCH W=0.6U L=0.06U M=1 $name=/taininv/P00
M146 NET485 NET527 VSS VSS NCH W=0.25U L=0.06U M=1 $name=/tain1/N00
M147 VDD NET527 NET485 VDD PCH W=0.5U L=0.06U M=1 $name=/tain1/P00
M148 NET487 NET490 VSS VSS NCH W=0.25U L=0.06U M=1 $name=/tain/N00
M149 VDD NET490 NET487 VDD PCH W=0.5U L=0.06U M=1 $name=/tain/P00
M15 YP1B AIND1B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P0/P00
M150 AI2_ NET490 VSS VSS NCH W=0.9U L=0.06U M=1 $name=/taidrv/N00
M151 VDD NET490 AI2_ VDD PCH W=1.8U L=0.06U M=1 $name=/taidrv/P00
M152 NET491 AIND7T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/gypselinv/N00
M153 VDD AIND7T_ NET491 VDD PCH W=0.3U L=0.06U M=1 $name=/gypselinv/P00
M154 BST BSTN VSS VSS NCH W=2U L=0.06U M=1 $name=/gbkselinv/N00
M155 VDD BSTN BST VDD PCH W=4U L=0.06U M=1 $name=/gbkselinv/P00
M156 YP0_7NT YP7T VSS VSS NCH W=4U L=0.06U M=1 $name=/gapydrv/N00
M157 VDD YP7T YP0_7NT VDD PCH W=8U L=0.06U M=1 $name=/gapydrv/P00
M158 NET497 AIND1T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I79/N00
M159 VDD AIND1T_ NET497 VDD PCH W=0.3U L=0.06U M=1 $name=/I79/P00
M16 YP7T AIND7T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/tnypdesel/N00
M160 NET365 AIND0T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I78/N00
M161 VDD AIND0T_ NET365 VDD PCH W=0.3U L=0.06U M=1 $name=/I78/P00
M162 NET368 AIND2T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I75/N00
M163 VDD AIND2T_ NET368 VDD PCH W=0.3U L=0.06U M=1 $name=/I75/P00
M164 NET503 AIND3T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I74/N00
M165 VDD AIND3T_ NET503 VDD PCH W=0.3U L=0.06U M=1 $name=/I74/P00
M166 NET505 AIND5T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I71/N00
M167 VDD AIND5T_ NET505 VDD PCH W=0.3U L=0.06U M=1 $name=/I71/P00
M168 NET377 AIND4T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I70/N00
M169 VDD AIND4T_ NET377 VDD PCH W=0.3U L=0.06U M=1 $name=/I70/P00
M17 YP7T NET491 BST VSS NCH W=2U L=0.06U M=1 $name=/tnpass/N00
M170 YP0_0NT YP0T VSS VSS NCH W=4U L=0.06U M=1 $name=/I67/N00
M171 VDD YP0T YP0_0NT VDD PCH W=8U L=0.06U M=1 $name=/I67/P00
M172 YP0_1NT YP1T VSS VSS NCH W=4U L=0.06U M=1 $name=/I66/N00
M173 VDD YP1T YP0_1NT VDD PCH W=8U L=0.06U M=1 $name=/I66/P00
M174 NET383 AIND6T_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I65/N00
M175 VDD AIND6T_ NET383 VDD PCH W=0.3U L=0.06U M=1 $name=/I65/P00
M176 YP0_6NT YP6T VSS VSS NCH W=4U L=0.06U M=1 $name=/I29/N00
M177 VDD YP6T YP0_6NT VDD PCH W=8U L=0.06U M=1 $name=/I29/P00
M178 NET524 AY0N VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I179/N00
M179 VDD AY0N NET524 VDD PCH W=0.6U L=0.06U M=1 $name=/I179/P00
M18 VSS AIND5B_ YP5B VSS NCH W=1U L=0.06U M=1 $name=/N9/N00
M180 NET519 NET524 VSS VSS NCH W=0.25U L=0.06U M=1 $name=/I178/N00
M181 VDD NET524 NET519 VDD PCH W=0.5U L=0.06U M=1 $name=/I178/P00
M182 AI0 NET519 VSS VSS NCH W=0.9U L=0.06U M=1 $name=/I177/N00
M183 VDD NET519 AI0 VDD PCH W=1.8U L=0.06U M=1 $name=/I177/P00
M184 AI0_ NET524 VSS VSS NCH W=0.9U L=0.06U M=1 $name=/I175/N00
M185 VDD NET524 AI0_ VDD PCH W=1.8U L=0.06U M=1 $name=/I175/P00
M186 AI1_ NET527 VSS VSS NCH W=0.9U L=0.06U M=1 $name=/I173/N00
M187 VDD NET527 AI1_ VDD PCH W=1.8U L=0.06U M=1 $name=/I173/P00
M188 NET527 AY1N VSS VSS NCH W=0.3U L=0.06U M=1 $name=/I172/N00
M189 VDD AY1N NET527 VDD PCH W=0.6U L=0.06U M=1 $name=/I172/P00
M19 YP4B AIND4B_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N8/N00
M190 AI1 NET485 VSS VSS NCH W=0.9U L=0.06U M=1 $name=/I171/N00
M191 VDD NET485 AI1 VDD PCH W=1.8U L=0.06U M=1 $name=/I171/P00
M192 NET395 AIND6B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I167/N00
M193 VDD AIND6B_ NET395 VDD PCH W=0.3U L=0.06U M=1 $name=/I167/P00
M194 NET533 AIND7B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I166/N00
M195 VDD AIND7B_ NET533 VDD PCH W=0.3U L=0.06U M=1 $name=/I166/P00
M196 YP0_6NB YP6B VSS VSS NCH W=4U L=0.06U M=1 $name=/I165/N00
M197 VDD YP6B YP0_6NB VDD PCH W=8U L=0.06U M=1 $name=/I165/P00
M198 YP0_7NB YP7B VSS VSS NCH W=4U L=0.06U M=1 $name=/I164/N00
M199 VDD YP7B YP0_7NB VDD PCH W=8U L=0.06U M=1 $name=/I164/P00
M2 YP7B AIND7B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P6/P00
M20 BSB NET335 YP2B VSS NCH W=2U L=0.06U M=1 $name=/N7/N00
M200 NET407 AIND4B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I161/N00
M201 VDD AIND4B_ NET407 VDD PCH W=0.3U L=0.06U M=1 $name=/I161/P00
M202 NET541 AIND5B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I160/N00
M203 VDD AIND5B_ NET541 VDD PCH W=0.3U L=0.06U M=1 $name=/I160/P00
M204 YP0_4NB YP4B VSS VSS NCH W=4U L=0.06U M=1 $name=/I159/N00
M205 VDD YP4B YP0_4NB VDD PCH W=8U L=0.06U M=1 $name=/I159/P00
M206 YP0_5NB YP5B VSS VSS NCH W=4U L=0.06U M=1 $name=/I158/N00
M207 VDD YP5B YP0_5NB VDD PCH W=8U L=0.06U M=1 $name=/I158/P00
M208 BSB BSBN VSS VSS NCH W=2U L=0.06U M=1 $name=/I157/N00
M209 VDD BSBN BSB VDD PCH W=4U L=0.06U M=1 $name=/I157/P00
M21 YP1T AIND1T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N62/N00
M210 NET335 AIND2B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I156/N00
M211 VDD AIND2B_ NET335 VDD PCH W=0.3U L=0.06U M=1 $name=/I156/P00
M212 NET551 AIND3B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I155/N00
M213 VDD AIND3B_ NET551 VDD PCH W=0.3U L=0.06U M=1 $name=/I155/P00
M214 YP0_3NB YP3B VSS VSS NCH W=4U L=0.06U M=1 $name=/I154/N00
M215 VDD YP3B YP0_3NB VDD PCH W=8U L=0.06U M=1 $name=/I154/P00
M216 YP0_2NB YP2B VSS VSS NCH W=4U L=0.06U M=1 $name=/I153/N00
M217 VDD YP2B YP0_2NB VDD PCH W=8U L=0.06U M=1 $name=/I153/P00
M218 NET389 AIND0B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I148/N00
M219 VDD AIND0B_ NET389 VDD PCH W=0.3U L=0.06U M=1 $name=/I148/P00
M22 YP0T AIND0T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N61/N00
M220 NET559 AIND1B_ VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I147/N00
M221 VDD AIND1B_ NET559 VDD PCH W=0.3U L=0.06U M=1 $name=/I147/P00
M222 YP0_1NB YP1B VSS VSS NCH W=4U L=0.06U M=1 $name=/I146/N00
M223 VDD YP1B YP0_1NB VDD PCH W=8U L=0.06U M=1 $name=/I146/P00
M224 YP0_0NB YP0B VSS VSS NCH W=4U L=0.06U M=1 $name=/I145/N00
M225 VDD YP0B YP0_0NB VDD PCH W=8U L=0.06U M=1 $name=/I145/P00
M226 YP0_2NT YP2T VSS VSS NCH W=4U L=0.06U M=1 $name=/I144/N00
M227 VDD YP2T YP0_2NT VDD PCH W=8U L=0.06U M=1 $name=/I144/P00
M228 YP0_3NT YP3T VSS VSS NCH W=4U L=0.06U M=1 $name=/I143/N00
M229 VDD YP3T YP0_3NT VDD PCH W=8U L=0.06U M=1 $name=/I143/P00
M23 YP2T AIND2T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N60/N00
M230 YP0_4NT YP4T VSS VSS NCH W=4U L=0.06U M=1 $name=/I142/N00
M231 VDD YP4T YP0_4NT VDD PCH W=8U L=0.06U M=1 $name=/I142/P00
M232 YP0_5NT YP5T VSS VSS NCH W=4U L=0.06U M=1 $name=/I141/N00
M233 VDD YP5T YP0_5NT VDD PCH W=8U L=0.06U M=1 $name=/I141/P00
M234 AI2 NET487 VSS VSS NCH W=0.9U L=0.06U M=1 $name=/I1/N00
M235 VDD NET487 AI2 VDD PCH W=1.8U L=0.06U M=1 $name=/I1/P00
M24 BSB NET551 YP3B VSS NCH W=2U L=0.06U M=1 $name=/N6/N00
M25 YP3T AIND3T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N59/N00
M26 YP4T AIND4T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N58/N00
M27 YP5T AIND5T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N57/N00
M28 YP6T AIND6T_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N56/N00
M29 YP1T NET497 BST VSS NCH W=2U L=0.06U M=1 $name=/N55/N00
M3 YP4B AIND4B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P5/P00
M30 YP0T NET365 BST VSS NCH W=2U L=0.06U M=1 $name=/N54/N00
M31 YP2T NET368 BST VSS NCH W=2U L=0.06U M=1 $name=/N53/N00
M32 YP3T NET503 BST VSS NCH W=2U L=0.06U M=1 $name=/N52/N00
M33 YP5T NET505 BST VSS NCH W=2U L=0.06U M=1 $name=/N51/N00
M34 YP4T NET377 BST VSS NCH W=2U L=0.06U M=1 $name=/N50/N00
M35 YP2B AIND2B_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N5/N00
M36 YP6T NET383 BST VSS NCH W=2U L=0.06U M=1 $name=/N49/N00
M37 VSS AIND3B_ YP3B VSS NCH W=1U L=0.06U M=1 $name=/N4/N00
M38 BSB NET389 YP0B VSS NCH W=2U L=0.06U M=1 $name=/N3/N00
M39 BSB NET559 YP1B VSS NCH W=2U L=0.06U M=1 $name=/N2/N00
M4 BST AIND0T_ YP0T VDD PCH W=2U L=0.06U M=1 $name=/P44/P00
M40 BSB NET395 YP6B VSS NCH W=2U L=0.06U M=1 $name=/N15/N00
M41 BSB NET533 YP7B VSS NCH W=2U L=0.06U M=1 $name=/N14/N00
M42 YP6B AIND6B_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N13/N00
M43 VSS AIND7B_ YP7B VSS NCH W=1U L=0.06U M=1 $name=/N12/N00
M44 BSB NET407 YP4B VSS NCH W=2U L=0.06U M=1 $name=/N11/N00
M45 BSB NET541 YP5B VSS NCH W=2U L=0.06U M=1 $name=/N10/N00
M46 VSS AIND1B_ YP1B VSS NCH W=1U L=0.06U M=1 $name=/N1/N00
M47 YP0B AIND0B_ VSS VSS NCH W=1U L=0.06U M=1 $name=/N0/N00
M48 HNET279 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/gypselnand/N02
M49 HNET280 AI1 HNET279 VSS NCH W=0.8U L=0.06U M=1 $name=/gypselnand/N01
M5 BST AIND1T_ YP1T VDD PCH W=2U L=0.06U M=1 $name=/P43/P00
M50 AIND7T_ AI0 HNET280 VSS NCH W=0.8U L=0.06U M=1 $name=/gypselnand/N00
M51 VDD AI2 AIND7T_ VDD PCH W=0.4U L=0.06U M=1 $name=/gypselnand/P20
M52 VDD AI1 AIND7T_ VDD PCH W=0.4U L=0.06U M=1 $name=/gypselnand/P10
M53 VDD AI0 AIND7T_ VDD PCH W=0.4U L=0.06U M=1 $name=/gypselnand/P00
M54 HNET286 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I77/N02
M55 HNET287 AI1_ HNET286 VSS NCH W=0.8U L=0.06U M=1 $name=/I77/N01
M56 AIND1T_ AI0 HNET287 VSS NCH W=0.8U L=0.06U M=1 $name=/I77/N00
M57 VDD AI2_ AIND1T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I77/P20
M58 VDD AI1_ AIND1T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I77/P10
M59 VDD AI0 AIND1T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I77/P00
M6 BST AIND2T_ YP2T VDD PCH W=2U L=0.06U M=1 $name=/P42/P00
M60 HNET293 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I76/N02
M61 HNET294 AI1_ HNET293 VSS NCH W=0.8U L=0.06U M=1 $name=/I76/N01
M62 AIND0T_ AI0_ HNET294 VSS NCH W=0.8U L=0.06U M=1 $name=/I76/N00
M63 VDD AI2_ AIND0T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I76/P20
M64 VDD AI1_ AIND0T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I76/P10
M65 VDD AI0_ AIND0T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I76/P00
M66 HNET300 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I73/N02
M67 HNET301 AI1 HNET300 VSS NCH W=0.8U L=0.06U M=1 $name=/I73/N01
M68 AIND2T_ AI0_ HNET301 VSS NCH W=0.8U L=0.06U M=1 $name=/I73/N00
M69 VDD AI2_ AIND2T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I73/P20
M7 BST AIND3T_ YP3T VDD PCH W=2U L=0.06U M=1 $name=/P41/P00
M70 VDD AI1 AIND2T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I73/P10
M71 VDD AI0_ AIND2T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I73/P00
M72 HNET307 AI2_ VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I72/N02
M73 HNET308 AI1 HNET307 VSS NCH W=0.8U L=0.06U M=1 $name=/I72/N01
M74 AIND3T_ AI0 HNET308 VSS NCH W=0.8U L=0.06U M=1 $name=/I72/N00
M75 VDD AI2_ AIND3T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I72/P20
M76 VDD AI1 AIND3T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I72/P10
M77 VDD AI0 AIND3T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I72/P00
M78 HNET314 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I69/N02
M79 HNET315 AI1_ HNET314 VSS NCH W=0.8U L=0.06U M=1 $name=/I69/N01
M8 BST AIND5T_ YP5T VDD PCH W=2U L=0.06U M=1 $name=/P40/P00
M80 AIND4T_ AI0_ HNET315 VSS NCH W=0.8U L=0.06U M=1 $name=/I69/N00
M81 VDD AI2 AIND4T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I69/P20
M82 VDD AI1_ AIND4T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I69/P10
M83 VDD AI0_ AIND4T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I69/P00
M84 HNET321 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I68/N02
M85 HNET322 AI1_ HNET321 VSS NCH W=0.8U L=0.06U M=1 $name=/I68/N01
M86 AIND5T_ AI0 HNET322 VSS NCH W=0.8U L=0.06U M=1 $name=/I68/N00
M87 VDD AI2 AIND5T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I68/P20
M88 VDD AI1_ AIND5T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I68/P10
M89 VDD AI0 AIND5T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I68/P00
M9 YP5B AIND5B_ BSB VDD PCH W=2U L=0.06U M=1 $name=/P4/P00
M90 HNET328 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I62/N02
M91 HNET329 AI1 HNET328 VSS NCH W=0.8U L=0.06U M=1 $name=/I62/N01
M92 AIND6T_ AI0_ HNET329 VSS NCH W=0.8U L=0.06U M=1 $name=/I62/N00
M93 VDD AI2 AIND6T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I62/P20
M94 VDD AI1 AIND6T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I62/P10
M95 VDD AI0_ AIND6T_ VDD PCH W=0.4U L=0.06U M=1 $name=/I62/P00
M96 HNET335 AI2 VSS VSS NCH W=0.8U L=0.06U M=1 $name=/I169/N02
M97 HNET336 AI1 HNET335 VSS NCH W=0.8U L=0.06U M=1 $name=/I169/N01
M98 AIND6B_ AI0_ HNET336 VSS NCH W=0.8U L=0.06U M=1 $name=/I169/N00
M99 VDD AI2 AIND6B_ VDD PCH W=0.4U L=0.06U M=1 $name=/I169/P20
.ENDS sram_AAPY
****
.SUBCKT sram_ACK AX5N AX6N AX6NB AX6NT AXIN BS0N BS0NB BS0NT BS1 BS1IN BS1N
+  BS1NB BS1NT BS2 BS2IN BS2N BSBN BSTN BTPCDBR BTPCDTR BTPSABR BTPSAR BTPSATR
+  BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1 BTPWNR DRPRENBR DRPRENTR GTP GTPB GTPD
+  GTPDB GTPDE GTPDET GTPDT GTPT LGWEN MBL_TERM MGDLE MGDLET MGDLS MGDLST
+  MGTPE MGTPET MGTPS MGTPST PBTPSABL PBTPSAL PBTPSATL PBTPWNL PDRPREBL
+  PDRPRETL PG_TERM PSAENL RDT RET RREN RRENB RRENT SAENR TIEHIGH TIELOW
+  YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T YP0_4B YP0_4T
+  YP0_5B YP0_5T YP0_6B YP0_6T YP0_7B YP0_7T VSS VDD
** sram_ACK: 238 flat devices **
M0 BLKSELT0 NET0591 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I50/N10
M1 BLKSELT0 NET574 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I50/N00
M10 VDD NET603 HNET162 VDD PCH W=0.3U L=0.06U M=1 $name=/I19/P01
M100 VSS RET BTPWDB1 VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N27/N00
M101 VSS RET BTPSAR VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N9/N00
M102 VSS RET BTPSATR VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N8/N00
M103 VSS RET BTPCDTR VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N7/N00
M104 VSS RET BTPWDT0 VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N6/N00
M105 VSS RET BTPSABR VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N4/N00
M106 VSS RET DRPRENTR VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N17/N00
M107 VSS RET BTPCDBR VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N13/N00
M108 VSS RET DRPRENBR VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N1/N00
M109 VSS RET BTPWDB0 VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N0/N00
M11 HNET162 NET577 BLKSELB0 VDD PCH W=0.3U L=0.06U M=1 $name=/I19/P00
M110 HNET363 NET387 VSS VSS NCH W=0.52U L=0.06U M=1 $name=/I63/N01
M111 NET616 GTP_CDSA HNET363 VSS NCH W=0.52U L=0.06U M=1 $name=/I63/N00
M112 VDD NET387 NET616 VDD PCH W=0.5U L=0.06U M=1 $name=/I63/P10
M113 VDD GTP_CDSA NET616 VDD PCH W=0.5U L=0.06U M=1 $name=/I63/P00
M114 HNET367 NET583 VSS VSS NCH W=2.1U L=0.06U M=1 $name=/I31/N01
M115 PBTPWNL NET0625 HNET367 VSS NCH W=2.1U L=0.06U M=1 $name=/I31/N00
M116 VDD NET583 PBTPWNL VDD PCH W=2.9U L=0.06U M=1 $name=/I31/P10
M117 VDD NET0625 PBTPWNL VDD PCH W=2.9U L=0.06U M=1 $name=/I31/P00
M118 HNET371 BS2IN VSS VSS NCH W=0.21U L=0.06U M=1 $name=/I67/N01
M119 NET0592 BS1IN HNET371 VSS NCH W=0.21U L=0.06U M=1 $name=/I67/N00
M12 BLKSELB1 AXIN VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I18/N10
M120 VDD BS2IN NET0592 VDD PCH W=0.15U L=0.06U M=1 $name=/I67/P10
M121 VDD BS1IN NET0592 VDD PCH W=0.15U L=0.06U M=1 $name=/I67/P00
M122 HNET375 BST VSS VSS NCH W=0.68U L=0.06U M=1 $name=/tnbst/N01
M123 NET574 NET611 HNET375 VSS NCH W=0.68U L=0.06U M=1 $name=/tnbst/N00
M124 VDD BST NET574 VDD PCH W=0.46U L=0.06U M=1 $name=/tnbst/P10
M125 VDD NET611 NET574 VDD PCH W=0.46U L=0.06U M=1 $name=/tnbst/P00
M126 HNET379 NET623 VSS VSS NCH W=0.68U L=0.06U M=1 $name=/tnbsb/N01
M127 NET577 NET611 HNET379 VSS NCH W=0.68U L=0.06U M=1 $name=/tnbsb/N00
M128 VDD NET623 NET577 VDD PCH W=0.46U L=0.06U M=1 $name=/tnbsb/P10
M129 VDD NET611 NET577 VDD PCH W=0.46U L=0.06U M=1 $name=/tnbsb/P00
M13 BLKSELB1 NET577 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I18/N00
M130 HNET383 GTPD VSS VSS NCH W=1.28U L=0.06U M=1 $name=/tgnd2lat/N01
M131 NET435 PSAENL HNET383 VSS NCH W=1.28U L=0.06U M=1 $name=/tgnd2lat/N00
M132 VDD GTPD NET435 VDD PCH W=0.88U L=0.06U M=1 $name=/tgnd2lat/P10
M133 VDD PSAENL NET435 VDD PCH W=0.88U L=0.06U M=1 $name=/tgnd2lat/P00
M134 HNET387 LGWE2 VSS VSS NCH W=0.9U L=0.06U M=1 $name=/tbtpwnnd2/N01
M135 NET583 GTP_CDSA HNET387 VSS NCH W=0.9U L=0.06U M=1 $name=/tbtpwnnd2/N00
M136 VDD LGWE2 NET583 VDD PCH W=0.8U L=0.06U M=1 $name=/tbtpwnnd2/P10
M137 VDD GTP_CDSA NET583 VDD PCH W=0.8U L=0.06U M=1 $name=/tbtpwnnd2/P00
M138 HNET391 NET587 VSS VSS NCH W=0.21U L=0.06U M=1 $name=/tbtpsnd2/N01
M139 NET586 NET611 HNET391 VSS NCH W=0.21U L=0.06U M=1 $name=/tbtpsnd2/N00
M14 VDD AXIN HNET167 VDD PCH W=0.3U L=0.06U M=1 $name=/I18/P01
M140 VDD NET587 NET586 VDD PCH W=0.15U L=0.06U M=1 $name=/tbtpsnd2/P10
M141 VDD NET611 NET586 VDD PCH W=0.15U L=0.06U M=1 $name=/tbtpsnd2/P00
M142 HNET395 NET423 VSS VSS NCH W=0.51U L=0.06U M=1 $name=/I62/N01
M143 NET618 GTP_CDSA HNET395 VSS NCH W=0.51U L=0.06U M=1 $name=/I62/N00
M144 VDD NET423 NET618 VDD PCH W=0.5U L=0.06U M=1 $name=/I62/P10
M145 VDD GTP_CDSA NET618 VDD PCH W=0.5U L=0.06U M=1 $name=/I62/P00
M146 NET0625 NET0627 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I36/N00
M147 VDD NET0627 NET0625 VDD PCH W=0.15U L=0.06U M=1 $name=/I36/P00
M148 NET0591 AXIN VSS VSS NCH W=0.31U L=0.06U M=1 $name=/I53/N00
M149 VDD AXIN NET0591 VDD PCH W=0.42U L=0.06U M=1 $name=/I53/P00
M15 HNET167 NET577 BLKSELB1 VDD PCH W=0.3U L=0.06U M=1 $name=/I18/P00
M150 BS2 BS2N VSS VSS NCH W=0.16U L=0.06U M=1 $name=/I65/N00
M151 VDD BS2N BS2 VDD PCH W=0.22U L=0.06U M=1 $name=/I65/P00
M152 GTPNT_WDT GTPT_WDT VSS VSS NCH W=1.2U L=0.06U M=1 $name=/I8/N00
M153 VDD GTPT_WDT GTPNT_WDT VDD PCH W=1.6U L=0.06U M=1 $name=/I8/P00
M154 BTPWDT1 GTPNT_WDT VSS VSS NCH W=2.49U L=0.06U M=1 $name=/I9/N00
M155 VDD GTPNT_WDT BTPWDT1 VDD PCH W=6U L=0.06U M=1 $name=/I9/P00
M156 BLKSELTN BLKSELT0 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I54/N00
M157 VDD BLKSELT0 BLKSELTN VDD PCH W=0.22U L=0.06U M=1 $name=/I54/P00
M158 BLKSELBNT BLKSELB1 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I58/N00
M159 VDD BLKSELB1 BLKSELBNT VDD PCH W=0.22U L=0.06U M=1 $name=/I58/P00
M16 RSELB LGWE2 VSS VSS NCH W=0.52U L=0.06U M=1 $name=/trselbnor2/N10
M160 NET654 NET574 VSS VSS NCH W=0.31U L=0.06U M=1 $name=/I48/N00
M161 VDD NET574 NET654 VDD PCH W=0.42U L=0.06U M=1 $name=/I48/P00
M162 NET603 AXIN VSS VSS NCH W=0.31U L=0.06U M=1 $name=/I56/N00
M163 VDD AXIN NET603 VDD PCH W=0.42U L=0.06U M=1 $name=/I56/P00
M164 GTPNB_WDT GTPB_WDT VSS VSS NCH W=1.2U L=0.06U M=1 $name=/I25/N00
M165 VDD GTPB_WDT GTPNB_WDT VDD PCH W=1.6U L=0.06U M=1 $name=/I25/P00
M166 NET611 NET0592 VSS VSS NCH W=0.22U L=0.06U M=1 $name=/I6/N00
M167 VDD NET0592 NET611 VDD PCH W=0.3U L=0.06U M=1 $name=/I6/P00
M168 BTPWDB1 GTPNB_WDT VSS VSS NCH W=2.49U L=0.06U M=1 $name=/I26/N00
M169 VDD GTPNB_WDT BTPWDB1 VDD PCH W=6U L=0.06U M=1 $name=/I26/P00
M17 RSELB BST VSS VSS NCH W=0.52U L=0.06U M=1 $name=/trselbnor2/N00
M170 BLKSELBN BLKSELB0 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I57/N00
M171 VDD BLKSELB0 BLKSELBN VDD PCH W=0.22U L=0.06U M=1 $name=/I57/P00
M172 BS1 BS1N VSS VSS NCH W=0.16U L=0.06U M=1 $name=/I7/N00
M173 VDD BS1N BS1 VDD PCH W=0.22U L=0.06U M=1 $name=/I7/P00
M174 NET615 NET616 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I4/N00
M175 VDD NET616 NET615 VDD PCH W=0.15U L=0.06U M=1 $name=/I4/P00
M176 NET617 NET618 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M177 VDD NET618 NET617 VDD PCH W=0.15U L=0.06U M=1 $name=/I1/P00
M178 BLKSELTNT BLKSELT1 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I55/N00
M179 VDD BLKSELT1 BLKSELTNT VDD PCH W=0.22U L=0.06U M=1 $name=/I55/P00
M18 VDD LGWE2 HNET172 VDD PCH W=1.4U L=0.06U M=1 $name=/trselbnor2/P01
M180 NET621 RREN VSS VSS NCH W=0.7U L=0.06U M=1 $name=/tsaseti/N00
M181 VDD RREN NET621 VDD PCH W=1U L=0.06U M=1 $name=/tsaseti/P00
M182 NET623 BST VSS VSS NCH W=0.45U L=0.06U M=1 $name=/tinvbs/N00
M183 VDD BST NET623 VDD PCH W=0.6U L=0.06U M=1 $name=/tinvbs/P00
M184 NET656 NET577 VSS VSS NCH W=0.31U L=0.06U M=1 $name=/tinv3/N00
M185 VDD NET577 NET656 VDD PCH W=0.42U L=0.06U M=1 $name=/tinv3/P00
M186 SASELN SASEL VSS VSS NCH W=0.64U L=0.06U M=1 $name=/tinv2/N00
M187 VDD SASEL SASELN VDD PCH W=0.86U L=0.06U M=1 $name=/tinv2/P00
M188 SASEL NET586 VSS VSS NCH W=0.54U L=0.06U M=1 $name=/tinv1/N00
M189 VDD NET586 SASEL VDD PCH W=0.73U L=0.06U M=1 $name=/tinv1/P00
M19 HNET172 BST RSELB VDD PCH W=1.4U L=0.06U M=1 $name=/trselbnor2/P00
M190 NET0627 NET583 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I35/N00
M191 VDD NET583 NET0627 VDD PCH W=0.15U L=0.06U M=1 $name=/I35/P00
M192 LGWE2 LGWEN VSS VSS NCH W=1.1U L=0.06U M=1 $name=/tbtpwninva/N00
M193 VDD LGWEN LGWE2 VDD PCH W=1.5U L=0.06U M=1 $name=/tbtpwninva/P00
M194 BTPWNR PBTPWNL VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpwn/N00
M195 VDD PBTPWNL BTPWNR VDD PCH W=10U L=0.06U M=1 $name=/tbtpwn/P00
M196 GTPNT_WD GTPT_WD VSS VSS NCH W=1.2U L=0.06U M=1 $name=/tbtpwdn/N00
M197 VDD GTPT_WD GTPNT_WD VDD PCH W=1.6U L=0.06U M=1 $name=/tbtpwdn/P00
M198 BTPWDT0 GTPNT_WD VSS VSS NCH W=2.49U L=0.06U M=1 $name=/tbtpwd/N00
M199 VDD GTPNT_WD BTPWDT0 VDD PCH W=6U L=0.06U M=1 $name=/tbtpwd/P00
M2 VDD NET0591 HNET152 VDD PCH W=0.3U L=0.06U M=1 $name=/I50/P01
M20 NET387 RDT VSS VSS NCH W=0.2U L=0.06U M=1 $name=/tnr2t/N10
M200 BTPSATR PBTPSATL VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpsatr/N00
M201 VDD PBTPSATL BTPSATR VDD PCH W=10U L=0.06U M=1 $name=/tbtpsatr/P00
M202 LGWEND LGWE2 VSS VSS NCH W=1U L=0.06U M=1 $name=/tbtpsapredrv6/N00
M203 VDD LGWE2 LGWEND VDD PCH W=1.4U L=0.06U M=1 $name=/tbtpsapredrv6/P00
M204 SAENR PSAENL VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpsaen/N00
M205 VDD PSAENL SAENR VDD PCH W=10U L=0.06U M=1 $name=/tbtpsaen/P00
M206 BTPSAR PBTPSAL VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpsa/N00
M207 VDD PBTPSAL BTPSAR VDD PCH W=10U L=0.06U M=1 $name=/tbtpsa/P00
M208 BTPCDTR CDPRET VSS VSS NCH W=5U L=0.06U M=1 $name=/tbtpcd/N00
M209 VDD CDPRET BTPCDTR VDD PCH W=10U L=0.06U M=1 $name=/tbtpcd/P00
M21 NET387 NET623 VSS VSS NCH W=0.2U L=0.06U M=1 $name=/tnr2t/N00
M210 BST BS0N VSS VSS NCH W=0.7U L=0.06U M=1 $name=/tbs0/N00
M211 VDD BS0N BST VDD PCH W=0.9U L=0.06U M=1 $name=/tbs0/P00
M212 BSTN NET654 VSS VSS NCH W=1.24U L=0.06U M=1 $name=/tbkselt2n/N00
M213 VDD NET654 BSTN VDD PCH W=1.68U L=0.06U M=1 $name=/tbkselt2n/P00
M214 BSBN NET656 VSS VSS NCH W=1.24U L=0.06U M=1 $name=/tbkselinv/N00
M215 VDD NET656 BSBN VDD PCH W=1.68U L=0.06U M=1 $name=/tbkselinv/P00
M216 NET657 NET615 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I5/N00
M217 VDD NET615 NET657 VDD PCH W=0.15U L=0.06U M=1 $name=/I5/P00
M218 CDPREB PDRPREBL VSS VSS NCH W=3.6U L=0.06U M=1 $name=/drprechdrvb/N00
M219 VDD PDRPREBL CDPREB VDD PCH W=5U L=0.06U M=1 $name=/drprechdrvb/P00
M22 VDD RDT HNET177 VDD PCH W=0.6U L=0.06U M=1 $name=/tnr2t/P01
M220 DRPRENBR CDPREB VSS VSS NCH W=5U L=0.06U M=1 $name=/drprechdrv/N00
M221 VDD CDPREB DRPRENBR VDD PCH W=10U L=0.06U M=1 $name=/drprechdrv/P00
M222 GTPNB_WD GTPB_WD VSS VSS NCH W=1.2U L=0.06U M=1 $name=/I210/N00
M223 VDD GTPB_WD GTPNB_WD VDD PCH W=1.6U L=0.06U M=1 $name=/I210/P00
M224 BTPCDBR CDPREB VSS VSS NCH W=5U L=0.06U M=1 $name=/I208/N00
M225 VDD CDPREB BTPCDBR VDD PCH W=10U L=0.06U M=1 $name=/I208/P00
M226 DRPRENTR CDPRET VSS VSS NCH W=5U L=0.06U M=1 $name=/I207/N00
M227 VDD CDPRET DRPRENTR VDD PCH W=10U L=0.06U M=1 $name=/I207/P00
M228 NET669 NET617 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I0/N00
M229 VDD NET617 NET669 VDD PCH W=0.15U L=0.06U M=1 $name=/I0/P00
M23 HNET177 NET623 NET387 VDD PCH W=0.6U L=0.06U M=1 $name=/tnr2t/P00
M230 CDPRET PDRPRETL VSS VSS NCH W=3.6U L=0.06U M=1 $name=/I205/N00
M231 VDD PDRPRETL CDPRET VDD PCH W=5U L=0.06U M=1 $name=/I205/P00
M232 NET587 RDT VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I191/N00
M233 VDD RDT NET587 VDD PCH W=0.2U L=0.06U M=1 $name=/I191/P00
M234 BTPWDB0 GTPNB_WD VSS VSS NCH W=2.49U L=0.06U M=1 $name=/I183/N00
M235 VDD GTPNB_WD BTPWDB0 VDD PCH W=6U L=0.06U M=1 $name=/I183/P00
M236 BTPSABR PBTPSABL VSS VSS NCH W=5U L=0.06U M=1 $name=/I175/N00
M237 VDD PBTPSABL BTPSABR VDD PCH W=10U L=0.06U M=1 $name=/I175/P00
M24 RSELT LGWE2 VSS VSS NCH W=0.52U L=0.06U M=1 $name=/tnr2prebtpsa/N10
M25 RSELT NET623 VSS VSS NCH W=0.52U L=0.06U M=1 $name=/tnr2prebtpsa/N00
M26 VDD LGWE2 HNET182 VDD PCH W=1.4U L=0.06U M=1 $name=/tnr2prebtpsa/P01
M27 HNET182 NET623 RSELT VDD PCH W=1.4U L=0.06U M=1 $name=/tnr2prebtpsa/P00
M28 NET423 RDT VSS VSS NCH W=0.2U L=0.06U M=1 $name=/tnr2b/N10
M29 NET423 BST VSS VSS NCH W=0.2U L=0.06U M=1 $name=/tnr2b/N00
M3 HNET152 NET574 BLKSELT0 VDD PCH W=0.3U L=0.06U M=1 $name=/I50/P00
M30 VDD RDT HNET187 VDD PCH W=0.6U L=0.06U M=1 $name=/tnr2b/P01
M31 HNET187 BST NET423 VDD PCH W=0.6U L=0.06U M=1 $name=/tnr2b/P00
M32 HNET195 NET616 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I64/N11
M33 PDRPRETL NET657 HNET195 VSS NCH W=1.25U L=0.06U M=1 $name=/I64/N10
M34 HNET193 NET616 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/I64/N01
M35 PDRPRETL NET657 HNET193 VSS NCH W=1.25U L=0.06U M=1 $name=/I64/N00
M36 VDD NET616 PDRPRETL VDD PCH W=2.5U L=0.06U M=1 $name=/I64/P10
M37 VDD NET657 PDRPRETL VDD PCH W=2.5U L=0.06U M=1 $name=/I64/P00
M38 HNET200 GTP_CDSA VSS VSS NCH W=1.16U L=0.06U M=1 $name=/tynand2/N11
M39 PBTPSATL RSELT HNET200 VSS NCH W=1.16U L=0.06U M=1 $name=/tynand2/N10
M4 BLKSELT1 AXIN VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I51/N10
M40 HNET198 GTP_CDSA VSS VSS NCH W=1.16U L=0.06U M=1 $name=/tynand2/N01
M41 PBTPSATL RSELT HNET198 VSS NCH W=1.16U L=0.06U M=1 $name=/tynand2/N00
M42 VDD GTP_CDSA PBTPSATL VDD PCH W=1.5U L=0.06U M=1 $name=/tynand2/P10
M43 VDD RSELT PBTPSATL VDD PCH W=1.5U L=0.06U M=1 $name=/tynand2/P00
M44 HNET205 GTP_CDSA VSS VSS NCH W=1.2U L=0.06U M=1 $name=/tnand2/N11
M45 PBTPSABL RSELB HNET205 VSS NCH W=1.2U L=0.06U M=1 $name=/tnand2/N10
M46 HNET203 GTP_CDSA VSS VSS NCH W=1.2U L=0.06U M=1 $name=/tnand2/N01
M47 PBTPSABL RSELB HNET203 VSS NCH W=1.2U L=0.06U M=1 $name=/tnand2/N00
M48 VDD GTP_CDSA PBTPSABL VDD PCH W=1.5U L=0.06U M=1 $name=/tnand2/P10
M49 VDD RSELB PBTPSABL VDD PCH W=1.5U L=0.06U M=1 $name=/tnand2/P00
M5 BLKSELT1 NET574 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I51/N00
M50 HNET210 LGWEND VSS VSS NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N11
M51 PBTPSAL GTP_CDSA HNET210 VSS NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N10
M52 HNET208 LGWEND VSS VSS NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N01
M53 PBTPSAL GTP_CDSA HNET208 VSS NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N00
M54 VDD LGWEND PBTPSAL VDD PCH W=2.7U L=0.06U M=1 $name=/tbtpsapredrvnd2/P10
M55 VDD GTP_CDSA PBTPSAL VDD PCH W=2.7U L=0.06U M=1 $name=/tbtpsapredrvnd2/P00
M56 HNET215 NET618 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N11
M57 PDRPREBL NET669 HNET215 VSS NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N10
M58 HNET213 NET618 VSS VSS NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N01
M59 PDRPREBL NET669 HNET213 VSS NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N00
M6 VDD AXIN HNET157 VDD PCH W=0.3U L=0.06U M=1 $name=/I51/P01
M60 VDD NET618 PDRPREBL VDD PCH W=2.5U L=0.06U M=1 $name=/drprechnd2b/P10
M61 VDD NET669 PDRPREBL VDD PCH W=2.5U L=0.06U M=1 $name=/drprechnd2b/P00
M62 GTPT_WDT BLKSELTNT GTP VDD PCH W=0.6U L=0.06U M=1 $name=/P0/P00
M63 GTPB_WDT BLKSELBNT GTP VDD PCH W=0.4U L=0.06U M=1 $name=/P4/P00
M64 GTPT_WD BLKSELTN GTP VDD PCH W=0.6U L=0.06U M=1 $name=/twdpgp/P00
M65 PSAENL NET435 NET436 VDD PCH W=5.2U L=0.06U M=1 $name=/tsasetp2/P00
M66 NET436 PBTPSAL PSAENL VDD PCH W=6U L=0.06U M=1 $name=/tsasetp1/P00
M67 VDD NET621 NET436 VDD PCH W=6U L=0.06U M=1 $name=/tsasetp/P00
M68 GTPB_WD BLKSELBN GTP VDD PCH W=0.4U L=0.06U M=1 $name=/tpp2/P00
M69 GTP_CDSA SASELN GTP VDD PCH W=4.98U L=0.06U M=1 $name=/tpp/P00
M7 HNET157 NET574 BLKSELT1 VDD PCH W=0.3U L=0.06U M=1 $name=/I51/P00
M70 VDD MGDLE VDD VDD PCH W=0.2U L=0.06U M=1 $name=/tpcapgdlload/P00
M71 VDD TIELOW TIEHIGH VDD PCH W=5.01U L=0.06U M=1 $name=/P8/P00
M72 VDD TIEHIGH TIEHIGH VDD PCH W=0.15U L=0.06U M=1 $name=/P3/P00
M73 VDD MGDLS VDD VDD PCH W=0.2U L=0.06U M=1 $name=/P2/P00
M74 VDD GTPDE VDD VDD PCH W=1.46U L=0.06U M=1 $name=/P10/P00
M75 GTPT_WDT BLKSELT1 GTP VSS NCH W=0.6U L=0.06U M=1 $name=/N16/N00
M76 GTPT_WDT BLKSELTNT VSS VSS NCH W=0.4U L=0.06U M=1 $name=/N18/N00
M77 NET473 NET435 VSS VSS NCH W=1.86U L=0.06U M=1 $name=/N11/N00
M78 PSAENL PBTPSAL NET485 VSS NCH W=1.86U L=0.06U M=1 $name=/N3/N00
M79 VSS BLKSELBNT GTPB_WDT VSS NCH W=0.4U L=0.06U M=1 $name=/N26/N00
M8 BLKSELB0 NET603 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I19/N10
M80 GTPB_WDT BLKSELB1 GTP VSS NCH W=0.4U L=0.06U M=1 $name=/N25/N00
M81 NET485 NET435 VSS VSS NCH W=1.86U L=0.06U M=1 $name=/N5/N00
M82 PSAENL PBTPSAL NET473 VSS NCH W=1.86U L=0.06U M=1 $name=/N10/N00
M83 GTPT_WD BLKSELT0 GTP VSS NCH W=0.6U L=0.06U M=1 $name=/twdpgn/N00
M84 NET494 NET435 VSS VSS NCH W=1.86U L=0.06U M=1 $name=/tsasetn2/N00
M85 PSAENL NET621 VSS VSS NCH W=2.28U L=0.06U M=1 $name=/tsasetn1/N00
M86 PSAENL PBTPSAL NET494 VSS NCH W=1.86U L=0.06U M=1 $name=/tsasetn/N00
M87 GTPB_WD BLKSELB0 GTP VSS NCH W=0.4U L=0.06U M=1 $name=/tpn2/N00
M88 GTP SASEL GTP_CDSA VSS NCH W=4.98U L=0.06U M=1 $name=/tpn/N00
M89 MGDLE TIELOW VSS VSS NCH W=1U L=0.06U M=1 $name=/tpdcapgdlload/N00
M9 BLKSELB0 NET577 VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I19/N00
M90 VSS BLKSELBN GTPB_WD VSS NCH W=0.4U L=0.06U M=1 $name=/tpd2/N00
M91 GTP_CDSA SASELN VSS VSS NCH W=2.66U L=0.06U M=1 $name=/tpd/N00
M92 VSS MGDLE VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tncapgdlload/N00
M93 GTPT_WD BLKSELTN VSS VSS NCH W=0.4U L=0.06U M=1 $name=/tdwdkpn/N00
M94 VSS GTPDE VSS VSS NCH W=2.12U L=0.06U M=1 $name=/N23/N00
M95 VSS MGDLS VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N22/N00
M96 TIELOW TIEHIGH VSS VSS NCH W=3U L=0.06U M=1 $name=/N20/N00
M97 TIELOW TIELOW VSS VSS NCH W=0.15U L=0.06U M=1 $name=/N2/N00
M98 MGDLS TIELOW VSS VSS NCH W=1U L=0.06U M=1 $name=/N15/N00
M99 VSS RET BTPWDT1 VSS NCH_HVT W=0.15U L=0.06U M=1 $name=/N19/N00
.ENDS sram_ACK
****
.SUBCKT sram_ALOCDECB0BT ATRACK0B ATRACK0T ATRACK1B ATRACK1T ATRACK2B ATRACK2T
+  ATRACK3B ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T AX6NT AY0NB AY0NT
+  AY1NB AY1NT AY2NB AY2NT BS0NT BS1NT BTPB BTPB2_TERM BTPB3_TERM BTPCDB
+  BTPCDBR BTPCDT BTPCDTR BTPSA BTPSABR BTPSAR BTPSATR BTPT BTPT2_TERM
+  BTPT3_TERM BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1 BTPWN BTPWNR DRPRENB DRPRENBR
+  DRPRENT DRPRENTR GTPB GTPDET GTPT LGWEN MBL_TERM MGDLET MGTPE MGTPET
+  PG_TERM_0 PG_TERM_1 RDT RET RRENB RRENT RXP0 RXP1 RXP2 RXP3 SAEN SAENR
+  TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0 XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4
+  XP4_ XP5 XP5_ YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T
+  YP0_4B YP0_4T YP0_5B YP0_5T YP0_6B YP0_6T YP0_7B YP0_7T VSS VDD
** sram_ALOCDECB0BT: 617 flat devices **
XI0 ATRACK0B ATRACK0B ATRACK0T ATRACK1B ATRACK1B ATRACK1T ATRACK2B ATRACK2B
+  ATRACK2T ATRACK3B ATRACK3B ATRACK3T ATRACK4B ATRACK4B ATRACK4T ATRACK5B
+  ATRACK5B ATRACK5T ATRACK5B TIEHIGHB BTPB BTPBN BTPCDB BTPCDT BTPSA BTPSAN
+  BTPT BTPTN BTPWN BTPWNN DRPRENB DRPRENT PDRPREB PDRPRET PG_TERM_1 RET SAEN
+  SAENN TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0 XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_
+  XP4 XP4_ XP5 XP5_ YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T
+  YP0_4B YP0_4T YP0_5B YP0_5T YP0_6B YP0_6T YP0_7B YP0_7T VSS VDD sram_AXP
XI1 ATRACK5B AY0NB AY0NB AY0NT AY1NB AY1NB AY1NT AY2NB AY2NB AY2NT BSBN BSTN
+  BTPB2_TERM BTPB3_TERM BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1
+  BTPSAN BTPBN BTPTN BTPWNN PDRPREB PDRPRET SAENN RET VSS VSS RXP0 RXP1 RXP2
+  RXP3 YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T YP0_4B YP0_4T
+  YP0_5B YP0_5T YP0_6B YP0_6T YP0_7B YP0_7T VSS VDD sram_AAPY
XI2 ATRACK5B AX6NT AX6NT AX6NT ATRACK5B BS0NT BS0NT BS0NT BS1 BS1NT BS1NT
+  BS1NT BS1NT BS2 AX6NT AX6NT BSBN BSTN BTPCDBR BTPCDTR BTPSABR BTPSAR
+  BTPSATR BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1 BTPWNR DRPRENBR DRPRENTR GTPB GTPB
+  GTPDET GTPDET GTPDET GTPDET GTPDET GTPT LGWEN MBL_TERM MGDLET MGDLET MGDLET
+  MGDLET MGTPE MGTPET MGTPE MGDLET BTPBN BTPSAN BTPTN BTPWNN PDRPREB PDRPRET
+  PG_TERM_0 SAENN RDT RET RRENB RRENB RRENT SAENR TIEHIGH MGDLET YP0_0B
+  YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T YP0_4B YP0_4T YP0_5B
+  YP0_5T YP0_6B YP0_6T YP0_7B YP0_7T VSS VDD sram_ACK
.ENDS sram_ALOCDECB0BT
****
.SUBCKT sram_ACDROWLB032T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0__0 BL0__1 BL0__2
+  BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12
+  BL0__13 BL0__14 BL0__15 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7
+  BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1__0 BL1__1 BL1__2
+  BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12
+  BL1__13 BL1__14 BL1__15 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7
+  BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2__0 BL2__1 BL2__2
+  BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11 BL2__12
+  BL2__13 BL2__14 BL2__15 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7
+  BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3__0 BL3__1 BL3__2
+  BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BL3__10 BL3__11 BL3__12
+  BL3__13 BL3__14 BL3__15 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7
+  BL4_8 BL4_9 BL4_10 BL4_11 BL4_12 BL4_13 BL4_14 BL4_15 BL4__0 BL4__1 BL4__2
+  BL4__3 BL4__4 BL4__5 BL4__6 BL4__7 BL4__8 BL4__9 BL4__10 BL4__11 BL4__12
+  BL4__13 BL4__14 BL4__15 BL5_0 BL5_1 BL5_2 BL5_3 BL5_4 BL5_5 BL5_6 BL5_7
+  BL5_8 BL5_9 BL5_10 BL5_11 BL5_12 BL5_13 BL5_14 BL5_15 BL5__0 BL5__1 BL5__2
+  BL5__3 BL5__4 BL5__5 BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11 BL5__12
+  BL5__13 BL5__14 BL5__15 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6 BL6_7
+  BL6_8 BL6_9 BL6_10 BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6__0 BL6__1 BL6__2
+  BL6__3 BL6__4 BL6__5 BL6__6 BL6__7 BL6__8 BL6__9 BL6__10 BL6__11 BL6__12
+  BL6__13 BL6__14 BL6__15 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6 BL7_7
+  BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7__0 BL7__1 BL7__2
+  BL7__3 BL7__4 BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11 BL7__12
+  BL7__13 BL7__14 BL7__15 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7
+  DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2 DR__3 DR__4
+  DR__5 DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13 DR__14 DR__15
+  DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13
+  DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9
+  DW__10 DW__11 DW__12 DW__13 DW__14 DW__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 TIELOW YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD
** sram_ACDROWLB032T: 1604 flat devices **
XCD81 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BL4_0 BL4__0 BL5_0
+  BL5__0 BL6_0 BL6__0 BL7_0 BL7__0 BTP DR_0 DRPREN DR__0 DW_0 DW__0 GDL_0
+  GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD810 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BL4_9 BL4__9 BL5_9
+  BL5__9 BL6_9 BL6__9 BL7_9 BL7__9 BTP DR_9 DRPREN DR__9 DW_9 DW__9 GDL_9
+  GDL__9 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD811 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BL4_10
+  BL4__10 BL5_10 BL5__10 BL6_10 BL6__10 BL7_10 BL7__10 BTP DR_10 DRPREN
+  DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD812 BL0_11 BL0__11 BL1_11 BL1__11 BL2_11 BL2__11 BL3_11 BL3__11 BL4_11
+  BL4__11 BL5_11 BL5__11 BL6_11 BL6__11 BL7_11 BL7__11 BTP DR_11 DRPREN
+  DR__11 DW_11 DW__11 GDL_11 GDL__11 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD813 BL0_12 BL0__12 BL1_12 BL1__12 BL2_12 BL2__12 BL3_12 BL3__12 BL4_12
+  BL4__12 BL5_12 BL5__12 BL6_12 BL6__12 BL7_12 BL7__12 BTP DR_12 DRPREN
+  DR__12 DW_12 DW__12 GDL_12 GDL__12 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD814 BL0_13 BL0__13 BL1_13 BL1__13 BL2_13 BL2__13 BL3_13 BL3__13 BL4_13
+  BL4__13 BL5_13 BL5__13 BL6_13 BL6__13 BL7_13 BL7__13 BTP DR_13 DRPREN
+  DR__13 DW_13 DW__13 GDL_13 GDL__13 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD815 BL0_14 BL0__14 BL1_14 BL1__14 BL2_14 BL2__14 BL3_14 BL3__14 BL4_14
+  BL4__14 BL5_14 BL5__14 BL6_14 BL6__14 BL7_14 BL7__14 BTP DR_14 DRPREN
+  DR__14 DW_14 DW__14 GDL_14 GDL__14 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD816 BL0_15 BL0__15 BL1_15 BL1__15 BL2_15 BL2__15 BL3_15 BL3__15 BL4_15
+  BL4__15 BL5_15 BL5__15 BL6_15 BL6__15 BL7_15 BL7__15 BTP DR_15 DRPREN
+  DR__15 DW_15 DW__15 GDL_15 GDL__15 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD82 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BL4_1 BL4__1 BL5_1
+  BL5__1 BL6_1 BL6__1 BL7_1 BL7__1 BTP DR_1 DRPREN DR__1 DW_1 DW__1 GDL_1
+  GDL__1 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD83 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BL4_2 BL4__2 BL5_2
+  BL5__2 BL6_2 BL6__2 BL7_2 BL7__2 BTP DR_2 DRPREN DR__2 DW_2 DW__2 GDL_2
+  GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD84 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BL4_3 BL4__3 BL5_3
+  BL5__3 BL6_3 BL6__3 BL7_3 BL7__3 BTP DR_3 DRPREN DR__3 DW_3 DW__3 GDL_3
+  GDL__3 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD85 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BL4_4 BL4__4 BL5_4
+  BL5__4 BL6_4 BL6__4 BL7_4 BL7__4 BTP DR_4 DRPREN DR__4 DW_4 DW__4 GDL_4
+  GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD86 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BL4_5 BL4__5 BL5_5
+  BL5__5 BL6_5 BL6__5 BL7_5 BL7__5 BTP DR_5 DRPREN DR__5 DW_5 DW__5 GDL_5
+  GDL__5 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD87 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BL4_6 BL4__6 BL5_6
+  BL5__6 BL6_6 BL6__6 BL7_6 BL7__6 BTP DR_6 DRPREN DR__6 DW_6 DW__6 GDL_6
+  GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD88 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BL4_7 BL4__7 BL5_7
+  BL5__7 BL6_7 BL6__7 BL7_7 BL7__7 BTP DR_7 DRPREN DR__7 DW_7 DW__7 GDL_7
+  GDL__7 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD89 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BL4_8 BL4__8 BL5_8
+  BL5__8 BL6_8 BL6__8 BL7_8 BL7__8 BTP DR_8 DRPREN DR__8 DW_8 DW__8 GDL_8
+  GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XI128 BTP DRPREN VSS TIELOW YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACDEDGE
.ENDS sram_ACDROWLB032T
****
.SUBCKT sram_ASA8 BTPB BTPSA BTPT BTPWN DRB DRB_ DRT DRT_ DW DW_ GDL GDLB
+  GDLB_ GDLT GDLT_ GDL_ SAEN VSS VDD
** sram_ASA8: 49 flat devices **
M0 VDD GDL NET179 VDD PCH W=0.24U L=0.06U M=1 $name=/P14/P00
M1 NET179 BTPWN NET300 VDD PCH W=0.24U L=0.06U M=1 $name=/P15/P00
M10 NET206 BTPWN NET190 VDD PCH W=0.24U L=0.06U M=1 $name=/P1/P00
M11 VDD SD SD_ VDD PCH W=0.2U L=0.06U M=1 $name=/tsdpu/P00
M12 SI SD NET211 VDD PCH W=0.5U L=0.06U M=1 $name=/tqbufp/P00
M13 SD SAENB VDD VDD PCH W=0.3U L=0.06U M=1 $name=/tpresd/P00
M14 DRT BTPTLB SD VDD PCH W=1.1U L=0.06U M=1 $name=/tdracc/P00
M15 SD_ SAENB SD VDD PCH W=0.3U L=0.06U M=1 $name=/P9/P00
M16 VDD SAENB SD_ VDD PCH W=0.3U L=0.06U M=1 $name=/P8/P00
M17 NET211 BTPSA VDD VDD PCH W=0.7U L=0.06U M=1 $name=/P63/P00
M18 DRT_ BTPTLB SD_ VDD PCH W=1.1U L=0.06U M=1 $name=/P5/P00
M19 DRB BTPBLB SD VDD PCH W=1.1U L=0.06U M=1 $name=/P4/P00
M2 VDD BTPSA NET203 VDD PCH W=0.35U L=0.06U M=1 $name=/P10/P00
M20 DRB_ BTPBLB SD_ VDD PCH W=1.1U L=0.06U M=1 $name=/P3/P00
M21 SD SD_ VDD VDD PCH W=0.2U L=0.06U M=1 $name=/P13/P00
M22 SI_ SD_ NET211 VDD PCH W=0.5U L=0.06U M=1 $name=/P0/P00
M23 VDD GDL_ NET206 VDD PCH W=0.24U L=0.06U M=1 $name=/tpprea/P00
M24 SE SAEN VSS VSS NCH W=0.3U L=0.06U M=1 $name=/N8/N00
M25 SE BTPSA VSS VSS NCH W=0.3U L=0.06U M=1 $name=/N9/N00
M26 NET190 GDL_ VSS VSS NCH W=0.18U L=0.06U M=1 $name=/tnpreb/N00
M27 NET190 BTPWN VSS VSS NCH W=0.18U L=0.06U M=1 $name=/N0/N00
M28 NET300 GDL VSS VSS NCH W=0.18U L=0.06U M=1 $name=/N7/N00
M29 SD_ SD SRC VSS NCH W=4U L=0.17U M=1 $name=/tsdpd/N00
M3 NET203 SAEN SE VDD PCH W=0.35U L=0.06U M=1 $name=/P12/P00
M30 VSS BTPSA SI VSS NCH W=0.13U L=0.06U M=1 $name=/tqbufn/N00
M31 VSS SE SRC VSS NCH W=4U L=0.17U M=1 $name=/tnpdsrc/N00
M32 GDL SI VSS VSS NCH W=2.8U L=0.06U M=1 $name=/tgdldrvn/N00
M33 NET300 BTPWN VSS VSS NCH W=0.18U L=0.06U M=1 $name=/N4/N00
M34 VSS SD SI VSS NCH W=0.18U L=0.06U M=1 $name=/N67/N00
M35 GDL_ SI_ VSS VSS NCH W=2.8U L=0.06U M=1 $name=/N6/N00
M36 SRC SD_ SD VSS NCH W=4U L=0.17U M=1 $name=/N5/N00
M37 SI_ SD_ VSS VSS NCH W=0.18U L=0.06U M=1 $name=/N3/N00
M38 SI_ BTPSA VSS VSS NCH W=0.18U L=0.06U M=1 $name=/N2/N00
M39 BTPTLB BTPT VSS VSS NCH W=0.15U L=0.06U M=1 $name=/tinvbtptlb/N00
M4 VDD BTPSA NET203 VDD PCH W=0.35U L=0.06U M=1 $name=/P11/P00
M40 VDD BTPT BTPTLB VDD PCH W=0.21U L=0.06U M=1 $name=/tinvbtptlb/P00
M41 DW NET300 VSS VSS NCH W=1.18U L=0.06U M=1 $name=/gdwt/N00
M42 VDD NET300 DW VDD PCH W=0.3U L=0.06U M=1 $name=/gdwt/P00
M43 DW_ NET190 VSS VSS NCH W=1.18U L=0.06U M=1 $name=/I39/N00
M44 VDD NET190 DW_ VDD PCH W=0.3U L=0.06U M=1 $name=/I39/P00
M45 BTPBLB BTPB VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I21/N00
M46 VDD BTPB BTPBLB VDD PCH W=0.21U L=0.06U M=1 $name=/I21/P00
M47 SAENB SAEN VSS VSS NCH W=0.15U L=0.06U M=1 $name=/I17/N00
M48 VDD SAEN SAENB VDD PCH W=0.15U L=0.06U M=1 $name=/I17/P00
M5 NET191 BTPWN NET190 VDD PCH W=0.24U L=0.06U M=1 $name=/P17/P00
M6 VDD GDL_ NET191 VDD PCH W=0.24U L=0.06U M=1 $name=/P16/P00
M7 NET197 BTPWN NET300 VDD PCH W=0.24U L=0.06U M=1 $name=/P2/P00
M8 VDD GDL NET197 VDD PCH W=0.24U L=0.06U M=1 $name=/P6/P00
M9 NET203 SAEN SE VDD PCH W=0.35U L=0.06U M=1 $name=/P7/P00
.ENDS sram_ASA8
****
.SUBCKT sram_ABSAROW32RT BTPB BTPSA BTPT BTPWN DRB_0 DRB_1 DRB_2 DRB_3 DRB_4
+  DRB_5 DRB_6 DRB_7 DRB_8 DRB_9 DRB_10 DRB_11 DRB_12 DRB_13 DRB_14 DRB_15
+  DRB__0 DRB__1 DRB__2 DRB__3 DRB__4 DRB__5 DRB__6 DRB__7 DRB__8 DRB__9
+  DRB__10 DRB__11 DRB__12 DRB__13 DRB__14 DRB__15 DRT_0 DRT_1 DRT_2 DRT_3
+  DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT_10 DRT_11 DRT_12 DRT_13 DRT_14
+  DRT_15 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8
+  DRT__9 DRT__10 DRT__11 DRT__12 DRT__13 DRT__14 DRT__15 DW_0 DW_1 DW_2 DW_3
+  DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15 DW__0
+  DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11 DW__12
+  DW__13 DW__14 DW__15 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6
+  GDLB_7 GDLB_8 GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15
+  GDLB__0 GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8
+  GDLB__9 GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14 GDLB__15 GDLT_0 GDLT_1
+  GDLT_2 GDLT_3 GDLT_4 GDLT_5 GDLT_6 GDLT_7 GDLT_8 GDLT_9 GDLT_10 GDLT_11
+  GDLT_12 GDLT_13 GDLT_14 GDLT_15 GDLT__0 GDLT__1 GDLT__2 GDLT__3 GDLT__4
+  GDLT__5 GDLT__6 GDLT__7 GDLT__8 GDLT__9 GDLT__10 GDLT__11 GDLT__12 GDLT__13
+  GDLT__14 GDLT__15 SAEN VSS VDD
** sram_ABSAROW32RT: 784 flat devices **
XSA81 BTPB BTPSA BTPT BTPWN DRB_0 DRB__0 DRT_0 DRT__0 DW_0 DW__0 GDLB_0 GDLB_0
+  GDLB__0 GDLT_0 GDLT__0 GDLB__0 SAEN VSS VDD sram_ASA8
XSA810 BTPB BTPSA BTPT BTPWN DRB_9 DRB__9 DRT_9 DRT__9 DW_9 DW__9 GDLB_9
+  GDLB_9 GDLB__9 GDLT_9 GDLT__9 GDLB__9 SAEN VSS VDD sram_ASA8
XSA811 BTPB BTPSA BTPT BTPWN DRB_10 DRB__10 DRT_10 DRT__10 DW_10 DW__10
+  GDLB_10 GDLB_10 GDLB__10 GDLT_10 GDLT__10 GDLB__10 SAEN VSS VDD sram_ASA8
XSA812 BTPB BTPSA BTPT BTPWN DRB_11 DRB__11 DRT_11 DRT__11 DW_11 DW__11
+  GDLB_11 GDLB_11 GDLB__11 GDLT_11 GDLT__11 GDLB__11 SAEN VSS VDD sram_ASA8
XSA813 BTPB BTPSA BTPT BTPWN DRB_12 DRB__12 DRT_12 DRT__12 DW_12 DW__12
+  GDLB_12 GDLB_12 GDLB__12 GDLT_12 GDLT__12 GDLB__12 SAEN VSS VDD sram_ASA8
XSA814 BTPB BTPSA BTPT BTPWN DRB_13 DRB__13 DRT_13 DRT__13 DW_13 DW__13
+  GDLB_13 GDLB_13 GDLB__13 GDLT_13 GDLT__13 GDLB__13 SAEN VSS VDD sram_ASA8
XSA815 BTPB BTPSA BTPT BTPWN DRB_14 DRB__14 DRT_14 DRT__14 DW_14 DW__14
+  GDLB_14 GDLB_14 GDLB__14 GDLT_14 GDLT__14 GDLB__14 SAEN VSS VDD sram_ASA8
XSA816 BTPB BTPSA BTPT BTPWN DRB_15 DRB__15 DRT_15 DRT__15 DW_15 DW__15
+  GDLB_15 GDLB_15 GDLB__15 GDLT_15 GDLT__15 GDLB__15 SAEN VSS VDD sram_ASA8
XSA82 BTPB BTPSA BTPT BTPWN DRB_1 DRB__1 DRT_1 DRT__1 DW_1 DW__1 GDLB_1 GDLB_1
+  GDLB__1 GDLT_1 GDLT__1 GDLB__1 SAEN VSS VDD sram_ASA8
XSA83 BTPB BTPSA BTPT BTPWN DRB_2 DRB__2 DRT_2 DRT__2 DW_2 DW__2 GDLB_2 GDLB_2
+  GDLB__2 GDLT_2 GDLT__2 GDLB__2 SAEN VSS VDD sram_ASA8
XSA84 BTPB BTPSA BTPT BTPWN DRB_3 DRB__3 DRT_3 DRT__3 DW_3 DW__3 GDLB_3 GDLB_3
+  GDLB__3 GDLT_3 GDLT__3 GDLB__3 SAEN VSS VDD sram_ASA8
XSA85 BTPB BTPSA BTPT BTPWN DRB_4 DRB__4 DRT_4 DRT__4 DW_4 DW__4 GDLB_4 GDLB_4
+  GDLB__4 GDLT_4 GDLT__4 GDLB__4 SAEN VSS VDD sram_ASA8
XSA86 BTPB BTPSA BTPT BTPWN DRB_5 DRB__5 DRT_5 DRT__5 DW_5 DW__5 GDLB_5 GDLB_5
+  GDLB__5 GDLT_5 GDLT__5 GDLB__5 SAEN VSS VDD sram_ASA8
XSA87 BTPB BTPSA BTPT BTPWN DRB_6 DRB__6 DRT_6 DRT__6 DW_6 DW__6 GDLB_6 GDLB_6
+  GDLB__6 GDLT_6 GDLT__6 GDLB__6 SAEN VSS VDD sram_ASA8
XSA88 BTPB BTPSA BTPT BTPWN DRB_7 DRB__7 DRT_7 DRT__7 DW_7 DW__7 GDLB_7 GDLB_7
+  GDLB__7 GDLT_7 GDLT__7 GDLB__7 SAEN VSS VDD sram_ASA8
XSA89 BTPB BTPSA BTPT BTPWN DRB_8 DRB__8 DRT_8 DRT__8 DW_8 DW__8 GDLB_8 GDLB_8
+  GDLB__8 GDLT_8 GDLT__8 GDLB__8 SAEN VSS VDD sram_ASA8
.ENDS sram_ABSAROW32RT
****
.SUBCKT sram_ABSAROW32LT BTPB BTPSA BTPT BTPWN DRB_0 DRB_1 DRB_2 DRB_3 DRB_4
+  DRB_5 DRB_6 DRB_7 DRB_8 DRB_9 DRB_10 DRB_11 DRB_12 DRB_13 DRB_14 DRB_15
+  DRB__0 DRB__1 DRB__2 DRB__3 DRB__4 DRB__5 DRB__6 DRB__7 DRB__8 DRB__9
+  DRB__10 DRB__11 DRB__12 DRB__13 DRB__14 DRB__15 DRT_0 DRT_1 DRT_2 DRT_3
+  DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT_10 DRT_11 DRT_12 DRT_13 DRT_14
+  DRT_15 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8
+  DRT__9 DRT__10 DRT__11 DRT__12 DRT__13 DRT__14 DRT__15 DW_0 DW_1 DW_2 DW_3
+  DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15 DW__0
+  DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11 DW__12
+  DW__13 DW__14 DW__15 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6
+  GDLB_7 GDLB_8 GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15
+  GDLB__0 GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8
+  GDLB__9 GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14 GDLB__15 GDLT_0 GDLT_1
+  GDLT_2 GDLT_3 GDLT_4 GDLT_5 GDLT_6 GDLT_7 GDLT_8 GDLT_9 GDLT_10 GDLT_11
+  GDLT_12 GDLT_13 GDLT_14 GDLT_15 GDLT__0 GDLT__1 GDLT__2 GDLT__3 GDLT__4
+  GDLT__5 GDLT__6 GDLT__7 GDLT__8 GDLT__9 GDLT__10 GDLT__11 GDLT__12 GDLT__13
+  GDLT__14 GDLT__15 SAEN VSS VDD
** sram_ABSAROW32LT: 784 flat devices **
XSA81 BTPB BTPSA BTPT BTPWN DRB_0 DRB__0 DRT_0 DRT__0 DW_0 DW__0 GDLB_0 GDLB_0
+  GDLB__0 GDLT_0 GDLT__0 GDLB__0 SAEN VSS VDD sram_ASA8
XSA810 BTPB BTPSA BTPT BTPWN DRB_9 DRB__9 DRT_9 DRT__9 DW_9 DW__9 GDLB_9
+  GDLB_9 GDLB__9 GDLT_9 GDLT__9 GDLB__9 SAEN VSS VDD sram_ASA8
XSA811 BTPB BTPSA BTPT BTPWN DRB_10 DRB__10 DRT_10 DRT__10 DW_10 DW__10
+  GDLB_10 GDLB_10 GDLB__10 GDLT_10 GDLT__10 GDLB__10 SAEN VSS VDD sram_ASA8
XSA812 BTPB BTPSA BTPT BTPWN DRB_11 DRB__11 DRT_11 DRT__11 DW_11 DW__11
+  GDLB_11 GDLB_11 GDLB__11 GDLT_11 GDLT__11 GDLB__11 SAEN VSS VDD sram_ASA8
XSA813 BTPB BTPSA BTPT BTPWN DRB_12 DRB__12 DRT_12 DRT__12 DW_12 DW__12
+  GDLB_12 GDLB_12 GDLB__12 GDLT_12 GDLT__12 GDLB__12 SAEN VSS VDD sram_ASA8
XSA814 BTPB BTPSA BTPT BTPWN DRB_13 DRB__13 DRT_13 DRT__13 DW_13 DW__13
+  GDLB_13 GDLB_13 GDLB__13 GDLT_13 GDLT__13 GDLB__13 SAEN VSS VDD sram_ASA8
XSA815 BTPB BTPSA BTPT BTPWN DRB_14 DRB__14 DRT_14 DRT__14 DW_14 DW__14
+  GDLB_14 GDLB_14 GDLB__14 GDLT_14 GDLT__14 GDLB__14 SAEN VSS VDD sram_ASA8
XSA816 BTPB BTPSA BTPT BTPWN DRB_15 DRB__15 DRT_15 DRT__15 DW_15 DW__15
+  GDLB_15 GDLB_15 GDLB__15 GDLT_15 GDLT__15 GDLB__15 SAEN VSS VDD sram_ASA8
XSA82 BTPB BTPSA BTPT BTPWN DRB_1 DRB__1 DRT_1 DRT__1 DW_1 DW__1 GDLB_1 GDLB_1
+  GDLB__1 GDLT_1 GDLT__1 GDLB__1 SAEN VSS VDD sram_ASA8
XSA83 BTPB BTPSA BTPT BTPWN DRB_2 DRB__2 DRT_2 DRT__2 DW_2 DW__2 GDLB_2 GDLB_2
+  GDLB__2 GDLT_2 GDLT__2 GDLB__2 SAEN VSS VDD sram_ASA8
XSA84 BTPB BTPSA BTPT BTPWN DRB_3 DRB__3 DRT_3 DRT__3 DW_3 DW__3 GDLB_3 GDLB_3
+  GDLB__3 GDLT_3 GDLT__3 GDLB__3 SAEN VSS VDD sram_ASA8
XSA85 BTPB BTPSA BTPT BTPWN DRB_4 DRB__4 DRT_4 DRT__4 DW_4 DW__4 GDLB_4 GDLB_4
+  GDLB__4 GDLT_4 GDLT__4 GDLB__4 SAEN VSS VDD sram_ASA8
XSA86 BTPB BTPSA BTPT BTPWN DRB_5 DRB__5 DRT_5 DRT__5 DW_5 DW__5 GDLB_5 GDLB_5
+  GDLB__5 GDLT_5 GDLT__5 GDLB__5 SAEN VSS VDD sram_ASA8
XSA87 BTPB BTPSA BTPT BTPWN DRB_6 DRB__6 DRT_6 DRT__6 DW_6 DW__6 GDLB_6 GDLB_6
+  GDLB__6 GDLT_6 GDLT__6 GDLB__6 SAEN VSS VDD sram_ASA8
XSA88 BTPB BTPSA BTPT BTPWN DRB_7 DRB__7 DRT_7 DRT__7 DW_7 DW__7 GDLB_7 GDLB_7
+  GDLB__7 GDLT_7 GDLT__7 GDLB__7 SAEN VSS VDD sram_ASA8
XSA89 BTPB BTPSA BTPT BTPWN DRB_8 DRB__8 DRT_8 DRT__8 DW_8 DW__8 GDLB_8 GDLB_8
+  GDLB__8 GDLT_8 GDLT__8 GDLB__8 SAEN VSS VDD sram_ASA8
.ENDS sram_ABSAROW32LT
****
.SUBCKT sram_ACDROWLT032T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0__0 BL0__1 BL0__2
+  BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12
+  BL0__13 BL0__14 BL0__15 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7
+  BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1__0 BL1__1 BL1__2
+  BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12
+  BL1__13 BL1__14 BL1__15 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7
+  BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2__0 BL2__1 BL2__2
+  BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11 BL2__12
+  BL2__13 BL2__14 BL2__15 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7
+  BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3__0 BL3__1 BL3__2
+  BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BL3__10 BL3__11 BL3__12
+  BL3__13 BL3__14 BL3__15 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7
+  BL4_8 BL4_9 BL4_10 BL4_11 BL4_12 BL4_13 BL4_14 BL4_15 BL4__0 BL4__1 BL4__2
+  BL4__3 BL4__4 BL4__5 BL4__6 BL4__7 BL4__8 BL4__9 BL4__10 BL4__11 BL4__12
+  BL4__13 BL4__14 BL4__15 BL5_0 BL5_1 BL5_2 BL5_3 BL5_4 BL5_5 BL5_6 BL5_7
+  BL5_8 BL5_9 BL5_10 BL5_11 BL5_12 BL5_13 BL5_14 BL5_15 BL5__0 BL5__1 BL5__2
+  BL5__3 BL5__4 BL5__5 BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11 BL5__12
+  BL5__13 BL5__14 BL5__15 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6 BL6_7
+  BL6_8 BL6_9 BL6_10 BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6__0 BL6__1 BL6__2
+  BL6__3 BL6__4 BL6__5 BL6__6 BL6__7 BL6__8 BL6__9 BL6__10 BL6__11 BL6__12
+  BL6__13 BL6__14 BL6__15 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6 BL7_7
+  BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7__0 BL7__1 BL7__2
+  BL7__3 BL7__4 BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11 BL7__12
+  BL7__13 BL7__14 BL7__15 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7
+  DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2 DR__3 DR__4
+  DR__5 DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13 DR__14 DR__15
+  DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13
+  DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9
+  DW__10 DW__11 DW__12 DW__13 DW__14 DW__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 TIELOW YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD
** sram_ACDROWLT032T: 1604 flat devices **
XCD81 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BL4_0 BL4__0 BL5_0
+  BL5__0 BL6_0 BL6__0 BL7_0 BL7__0 BTP DR_0 DRPREN DR__0 DW_0 DW__0 GDL_0
+  GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD810 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BL4_9 BL4__9 BL5_9
+  BL5__9 BL6_9 BL6__9 BL7_9 BL7__9 BTP DR_9 DRPREN DR__9 DW_9 DW__9 GDL_9
+  GDL__9 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD811 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BL4_10
+  BL4__10 BL5_10 BL5__10 BL6_10 BL6__10 BL7_10 BL7__10 BTP DR_10 DRPREN
+  DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD812 BL0_11 BL0__11 BL1_11 BL1__11 BL2_11 BL2__11 BL3_11 BL3__11 BL4_11
+  BL4__11 BL5_11 BL5__11 BL6_11 BL6__11 BL7_11 BL7__11 BTP DR_11 DRPREN
+  DR__11 DW_11 DW__11 GDL_11 GDL__11 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD813 BL0_12 BL0__12 BL1_12 BL1__12 BL2_12 BL2__12 BL3_12 BL3__12 BL4_12
+  BL4__12 BL5_12 BL5__12 BL6_12 BL6__12 BL7_12 BL7__12 BTP DR_12 DRPREN
+  DR__12 DW_12 DW__12 GDL_12 GDL__12 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD814 BL0_13 BL0__13 BL1_13 BL1__13 BL2_13 BL2__13 BL3_13 BL3__13 BL4_13
+  BL4__13 BL5_13 BL5__13 BL6_13 BL6__13 BL7_13 BL7__13 BTP DR_13 DRPREN
+  DR__13 DW_13 DW__13 GDL_13 GDL__13 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD815 BL0_14 BL0__14 BL1_14 BL1__14 BL2_14 BL2__14 BL3_14 BL3__14 BL4_14
+  BL4__14 BL5_14 BL5__14 BL6_14 BL6__14 BL7_14 BL7__14 BTP DR_14 DRPREN
+  DR__14 DW_14 DW__14 GDL_14 GDL__14 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACD8
XCD816 BL0_15 BL0__15 BL1_15 BL1__15 BL2_15 BL2__15 BL3_15 BL3__15 BL4_15
+  BL4__15 BL5_15 BL5__15 BL6_15 BL6__15 BL7_15 BL7__15 BTP DR_15 DRPREN
+  DR__15 DW_15 DW__15 GDL_15 GDL__15 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSS VDD sram_ACD8
XCD82 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BL4_1 BL4__1 BL5_1
+  BL5__1 BL6_1 BL6__1 BL7_1 BL7__1 BTP DR_1 DRPREN DR__1 DW_1 DW__1 GDL_1
+  GDL__1 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD83 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BL4_2 BL4__2 BL5_2
+  BL5__2 BL6_2 BL6__2 BL7_2 BL7__2 BTP DR_2 DRPREN DR__2 DW_2 DW__2 GDL_2
+  GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD84 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BL4_3 BL4__3 BL5_3
+  BL5__3 BL6_3 BL6__3 BL7_3 BL7__3 BTP DR_3 DRPREN DR__3 DW_3 DW__3 GDL_3
+  GDL__3 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD85 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BL4_4 BL4__4 BL5_4
+  BL5__4 BL6_4 BL6__4 BL7_4 BL7__4 BTP DR_4 DRPREN DR__4 DW_4 DW__4 GDL_4
+  GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD86 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BL4_5 BL4__5 BL5_5
+  BL5__5 BL6_5 BL6__5 BL7_5 BL7__5 BTP DR_5 DRPREN DR__5 DW_5 DW__5 GDL_5
+  GDL__5 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD87 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BL4_6 BL4__6 BL5_6
+  BL5__6 BL6_6 BL6__6 BL7_6 BL7__6 BTP DR_6 DRPREN DR__6 DW_6 DW__6 GDL_6
+  GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XCD88 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BL4_7 BL4__7 BL5_7
+  BL5__7 BL6_7 BL6__7 BL7_7 BL7__7 BTP DR_7 DRPREN DR__7 DW_7 DW__7 GDL_7
+  GDL__7 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSS VDD sram_ACD8
XCD89 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BL4_8 BL4__8 BL5_8
+  BL5__8 BL6_8 BL6__8 BL7_8 BL7__8 BTP DR_8 DRPREN DR__8 DW_8 DW__8 GDL_8
+  GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSS VDD sram_ACD8
XI128 BTP DRPREN VSS TIELOW YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACDEDGE
.ENDS sram_ACDROWLT032T
****
.SUBCKT sram_ACHB0_32M8BT ATRACK0B ATRACK0T ATRACK1B ATRACK1T ATRACK2B
+  ATRACK2T ATRACK3B ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T AX6NT AY0NB
+  AY0NT AY1NB AY1NT AY2NB AY2NT BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17
+  BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27
+  BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36 BL0_37
+  BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46 BL0_47
+  BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56 BL0_57
+  BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0_63 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13
+  BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22
+  BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31
+  BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40
+  BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46 BL0__47 BL0__48 BL0__49
+  BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58
+  BL0__59 BL0__60 BL0__61 BL0__62 BL0__63 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5
+  BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1_16
+  BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24 BL1_25 BL1_26
+  BL1_27 BL1_28 BL1_29 BL1_30 BL1_31 BL1_32 BL1_33 BL1_34 BL1_35 BL1_36
+  BL1_37 BL1_38 BL1_39 BL1_40 BL1_41 BL1_42 BL1_43 BL1_44 BL1_45 BL1_46
+  BL1_47 BL1_48 BL1_49 BL1_50 BL1_51 BL1_52 BL1_53 BL1_54 BL1_55 BL1_56
+  BL1_57 BL1_58 BL1_59 BL1_60 BL1_61 BL1_62 BL1_63 BL1__0 BL1__1 BL1__2
+  BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12
+  BL1__13 BL1__14 BL1__15 BL1__16 BL1__17 BL1__18 BL1__19 BL1__20 BL1__21
+  BL1__22 BL1__23 BL1__24 BL1__25 BL1__26 BL1__27 BL1__28 BL1__29 BL1__30
+  BL1__31 BL1__32 BL1__33 BL1__34 BL1__35 BL1__36 BL1__37 BL1__38 BL1__39
+  BL1__40 BL1__41 BL1__42 BL1__43 BL1__44 BL1__45 BL1__46 BL1__47 BL1__48
+  BL1__49 BL1__50 BL1__51 BL1__52 BL1__53 BL1__54 BL1__55 BL1__56 BL1__57
+  BL1__58 BL1__59 BL1__60 BL1__61 BL1__62 BL1__63 BL2_0 BL2_1 BL2_2 BL2_3
+  BL2_4 BL2_5 BL2_6 BL2_7 BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14
+  BL2_15 BL2_16 BL2_17 BL2_18 BL2_19 BL2_20 BL2_21 BL2_22 BL2_23 BL2_24
+  BL2_25 BL2_26 BL2_27 BL2_28 BL2_29 BL2_30 BL2_31 BL2_32 BL2_33 BL2_34
+  BL2_35 BL2_36 BL2_37 BL2_38 BL2_39 BL2_40 BL2_41 BL2_42 BL2_43 BL2_44
+  BL2_45 BL2_46 BL2_47 BL2_48 BL2_49 BL2_50 BL2_51 BL2_52 BL2_53 BL2_54
+  BL2_55 BL2_56 BL2_57 BL2_58 BL2_59 BL2_60 BL2_61 BL2_62 BL2_63 BL2__0
+  BL2__1 BL2__2 BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10
+  BL2__11 BL2__12 BL2__13 BL2__14 BL2__15 BL2__16 BL2__17 BL2__18 BL2__19
+  BL2__20 BL2__21 BL2__22 BL2__23 BL2__24 BL2__25 BL2__26 BL2__27 BL2__28
+  BL2__29 BL2__30 BL2__31 BL2__32 BL2__33 BL2__34 BL2__35 BL2__36 BL2__37
+  BL2__38 BL2__39 BL2__40 BL2__41 BL2__42 BL2__43 BL2__44 BL2__45 BL2__46
+  BL2__47 BL2__48 BL2__49 BL2__50 BL2__51 BL2__52 BL2__53 BL2__54 BL2__55
+  BL2__56 BL2__57 BL2__58 BL2__59 BL2__60 BL2__61 BL2__62 BL2__63 BL3_0 BL3_1
+  BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7 BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13
+  BL3_14 BL3_15 BL3_16 BL3_17 BL3_18 BL3_19 BL3_20 BL3_21 BL3_22 BL3_23
+  BL3_24 BL3_25 BL3_26 BL3_27 BL3_28 BL3_29 BL3_30 BL3_31 BL3_32 BL3_33
+  BL3_34 BL3_35 BL3_36 BL3_37 BL3_38 BL3_39 BL3_40 BL3_41 BL3_42 BL3_43
+  BL3_44 BL3_45 BL3_46 BL3_47 BL3_48 BL3_49 BL3_50 BL3_51 BL3_52 BL3_53
+  BL3_54 BL3_55 BL3_56 BL3_57 BL3_58 BL3_59 BL3_60 BL3_61 BL3_62 BL3_63
+  BL3__0 BL3__1 BL3__2 BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9
+  BL3__10 BL3__11 BL3__12 BL3__13 BL3__14 BL3__15 BL3__16 BL3__17 BL3__18
+  BL3__19 BL3__20 BL3__21 BL3__22 BL3__23 BL3__24 BL3__25 BL3__26 BL3__27
+  BL3__28 BL3__29 BL3__30 BL3__31 BL3__32 BL3__33 BL3__34 BL3__35 BL3__36
+  BL3__37 BL3__38 BL3__39 BL3__40 BL3__41 BL3__42 BL3__43 BL3__44 BL3__45
+  BL3__46 BL3__47 BL3__48 BL3__49 BL3__50 BL3__51 BL3__52 BL3__53 BL3__54
+  BL3__55 BL3__56 BL3__57 BL3__58 BL3__59 BL3__60 BL3__61 BL3__62 BL3__63
+  BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7 BL4_8 BL4_9 BL4_10 BL4_11
+  BL4_12 BL4_13 BL4_14 BL4_15 BL4_16 BL4_17 BL4_18 BL4_19 BL4_20 BL4_21
+  BL4_22 BL4_23 BL4_24 BL4_25 BL4_26 BL4_27 BL4_28 BL4_29 BL4_30 BL4_31
+  BL4_32 BL4_33 BL4_34 BL4_35 BL4_36 BL4_37 BL4_38 BL4_39 BL4_40 BL4_41
+  BL4_42 BL4_43 BL4_44 BL4_45 BL4_46 BL4_47 BL4_48 BL4_49 BL4_50 BL4_51
+  BL4_52 BL4_53 BL4_54 BL4_55 BL4_56 BL4_57 BL4_58 BL4_59 BL4_60 BL4_61
+  BL4_62 BL4_63 BL4__0 BL4__1 BL4__2 BL4__3 BL4__4 BL4__5 BL4__6 BL4__7
+  BL4__8 BL4__9 BL4__10 BL4__11 BL4__12 BL4__13 BL4__14 BL4__15 BL4__16
+  BL4__17 BL4__18 BL4__19 BL4__20 BL4__21 BL4__22 BL4__23 BL4__24 BL4__25
+  BL4__26 BL4__27 BL4__28 BL4__29 BL4__30 BL4__31 BL4__32 BL4__33 BL4__34
+  BL4__35 BL4__36 BL4__37 BL4__38 BL4__39 BL4__40 BL4__41 BL4__42 BL4__43
+  BL4__44 BL4__45 BL4__46 BL4__47 BL4__48 BL4__49 BL4__50 BL4__51 BL4__52
+  BL4__53 BL4__54 BL4__55 BL4__56 BL4__57 BL4__58 BL4__59 BL4__60 BL4__61
+  BL4__62 BL4__63 BL5_0 BL5_1 BL5_2 BL5_3 BL5_4 BL5_5 BL5_6 BL5_7 BL5_8 BL5_9
+  BL5_10 BL5_11 BL5_12 BL5_13 BL5_14 BL5_15 BL5_16 BL5_17 BL5_18 BL5_19
+  BL5_20 BL5_21 BL5_22 BL5_23 BL5_24 BL5_25 BL5_26 BL5_27 BL5_28 BL5_29
+  BL5_30 BL5_31 BL5_32 BL5_33 BL5_34 BL5_35 BL5_36 BL5_37 BL5_38 BL5_39
+  BL5_40 BL5_41 BL5_42 BL5_43 BL5_44 BL5_45 BL5_46 BL5_47 BL5_48 BL5_49
+  BL5_50 BL5_51 BL5_52 BL5_53 BL5_54 BL5_55 BL5_56 BL5_57 BL5_58 BL5_59
+  BL5_60 BL5_61 BL5_62 BL5_63 BL5__0 BL5__1 BL5__2 BL5__3 BL5__4 BL5__5
+  BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11 BL5__12 BL5__13 BL5__14 BL5__15
+  BL5__16 BL5__17 BL5__18 BL5__19 BL5__20 BL5__21 BL5__22 BL5__23 BL5__24
+  BL5__25 BL5__26 BL5__27 BL5__28 BL5__29 BL5__30 BL5__31 BL5__32 BL5__33
+  BL5__34 BL5__35 BL5__36 BL5__37 BL5__38 BL5__39 BL5__40 BL5__41 BL5__42
+  BL5__43 BL5__44 BL5__45 BL5__46 BL5__47 BL5__48 BL5__49 BL5__50 BL5__51
+  BL5__52 BL5__53 BL5__54 BL5__55 BL5__56 BL5__57 BL5__58 BL5__59 BL5__60
+  BL5__61 BL5__62 BL5__63 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6 BL6_7
+  BL6_8 BL6_9 BL6_10 BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6_16 BL6_17 BL6_18
+  BL6_19 BL6_20 BL6_21 BL6_22 BL6_23 BL6_24 BL6_25 BL6_26 BL6_27 BL6_28
+  BL6_29 BL6_30 BL6_31 BL6_32 BL6_33 BL6_34 BL6_35 BL6_36 BL6_37 BL6_38
+  BL6_39 BL6_40 BL6_41 BL6_42 BL6_43 BL6_44 BL6_45 BL6_46 BL6_47 BL6_48
+  BL6_49 BL6_50 BL6_51 BL6_52 BL6_53 BL6_54 BL6_55 BL6_56 BL6_57 BL6_58
+  BL6_59 BL6_60 BL6_61 BL6_62 BL6_63 BL6__0 BL6__1 BL6__2 BL6__3 BL6__4
+  BL6__5 BL6__6 BL6__7 BL6__8 BL6__9 BL6__10 BL6__11 BL6__12 BL6__13 BL6__14
+  BL6__15 BL6__16 BL6__17 BL6__18 BL6__19 BL6__20 BL6__21 BL6__22 BL6__23
+  BL6__24 BL6__25 BL6__26 BL6__27 BL6__28 BL6__29 BL6__30 BL6__31 BL6__32
+  BL6__33 BL6__34 BL6__35 BL6__36 BL6__37 BL6__38 BL6__39 BL6__40 BL6__41
+  BL6__42 BL6__43 BL6__44 BL6__45 BL6__46 BL6__47 BL6__48 BL6__49 BL6__50
+  BL6__51 BL6__52 BL6__53 BL6__54 BL6__55 BL6__56 BL6__57 BL6__58 BL6__59
+  BL6__60 BL6__61 BL6__62 BL6__63 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6
+  BL7_7 BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7_16 BL7_17
+  BL7_18 BL7_19 BL7_20 BL7_21 BL7_22 BL7_23 BL7_24 BL7_25 BL7_26 BL7_27
+  BL7_28 BL7_29 BL7_30 BL7_31 BL7_32 BL7_33 BL7_34 BL7_35 BL7_36 BL7_37
+  BL7_38 BL7_39 BL7_40 BL7_41 BL7_42 BL7_43 BL7_44 BL7_45 BL7_46 BL7_47
+  BL7_48 BL7_49 BL7_50 BL7_51 BL7_52 BL7_53 BL7_54 BL7_55 BL7_56 BL7_57
+  BL7_58 BL7_59 BL7_60 BL7_61 BL7_62 BL7_63 BL7__0 BL7__1 BL7__2 BL7__3
+  BL7__4 BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11 BL7__12 BL7__13
+  BL7__14 BL7__15 BL7__16 BL7__17 BL7__18 BL7__19 BL7__20 BL7__21 BL7__22
+  BL7__23 BL7__24 BL7__25 BL7__26 BL7__27 BL7__28 BL7__29 BL7__30 BL7__31
+  BL7__32 BL7__33 BL7__34 BL7__35 BL7__36 BL7__37 BL7__38 BL7__39 BL7__40
+  BL7__41 BL7__42 BL7__43 BL7__44 BL7__45 BL7__46 BL7__47 BL7__48 BL7__49
+  BL7__50 BL7__51 BL7__52 BL7__53 BL7__54 BL7__55 BL7__56 BL7__57 BL7__58
+  BL7__59 BL7__60 BL7__61 BL7__62 BL7__63 BS0NT BS1NT BTPB2_TERM BTPB3_TERM
+  BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53
+  GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63
+  GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18
+  GDL__19 GDL__20 GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27
+  GDL__28 GDL__29 GDL__30 GDL__31 GDL__32 GDL__33 GDL__34 GDL__35 GDL__36
+  GDL__37 GDL__38 GDL__39 GDL__40 GDL__41 GDL__42 GDL__43 GDL__44 GDL__45
+  GDL__46 GDL__47 GDL__48 GDL__49 GDL__50 GDL__51 GDL__52 GDL__53 GDL__54
+  GDL__55 GDL__56 GDL__57 GDL__58 GDL__59 GDL__60 GDL__61 GDL__62 GDL__63
+  GTPB GTPDET GTPT LGWEN MBL_TERM MGDLET MGTPE MGTPET RDT RET RRENB RRENT
+  RXP0 RXP1 RXP2 RXP3 TIEHIGHB TIEHIGHT TIELOWB TIELOWT TIELOW_0 TIELOW_1
+  TIELOW_2 TIELOW_3 XP0 XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ VSS
+  VDD
** sram_ACHB0_32M8BT: 8601 flat devices **
XLEFTBOTCDROW BL0_47 BL0_46 BL0_45 BL0_44 BL0_43 BL0_42 BL0_41 BL0_40 BL0_39
+  BL0_38 BL0_37 BL0_36 BL0_35 BL0_34 BL0_33 BL0_32 BL0__47 BL0__46 BL0__45
+  BL0__44 BL0__43 BL0__42 BL0__41 BL0__40 BL0__39 BL0__38 BL0__37 BL0__36
+  BL0__35 BL0__34 BL0__33 BL0__32 BL1_47 BL1_46 BL1_45 BL1_44 BL1_43 BL1_42
+  BL1_41 BL1_40 BL1_39 BL1_38 BL1_37 BL1_36 BL1_35 BL1_34 BL1_33 BL1_32
+  BL1__47 BL1__46 BL1__45 BL1__44 BL1__43 BL1__42 BL1__41 BL1__40 BL1__39
+  BL1__38 BL1__37 BL1__36 BL1__35 BL1__34 BL1__33 BL1__32 BL2_47 BL2_46
+  BL2_45 BL2_44 BL2_43 BL2_42 BL2_41 BL2_40 BL2_39 BL2_38 BL2_37 BL2_36
+  BL2_35 BL2_34 BL2_33 BL2_32 BL2__47 BL2__46 BL2__45 BL2__44 BL2__43 BL2__42
+  BL2__41 BL2__40 BL2__39 BL2__38 BL2__37 BL2__36 BL2__35 BL2__34 BL2__33
+  BL2__32 BL3_47 BL3_46 BL3_45 BL3_44 BL3_43 BL3_42 BL3_41 BL3_40 BL3_39
+  BL3_38 BL3_37 BL3_36 BL3_35 BL3_34 BL3_33 BL3_32 BL3__47 BL3__46 BL3__45
+  BL3__44 BL3__43 BL3__42 BL3__41 BL3__40 BL3__39 BL3__38 BL3__37 BL3__36
+  BL3__35 BL3__34 BL3__33 BL3__32 BL4_47 BL4_46 BL4_45 BL4_44 BL4_43 BL4_42
+  BL4_41 BL4_40 BL4_39 BL4_38 BL4_37 BL4_36 BL4_35 BL4_34 BL4_33 BL4_32
+  BL4__47 BL4__46 BL4__45 BL4__44 BL4__43 BL4__42 BL4__41 BL4__40 BL4__39
+  BL4__38 BL4__37 BL4__36 BL4__35 BL4__34 BL4__33 BL4__32 BL5_47 BL5_46
+  BL5_45 BL5_44 BL5_43 BL5_42 BL5_41 BL5_40 BL5_39 BL5_38 BL5_37 BL5_36
+  BL5_35 BL5_34 BL5_33 BL5_32 BL5__47 BL5__46 BL5__45 BL5__44 BL5__43 BL5__42
+  BL5__41 BL5__40 BL5__39 BL5__38 BL5__37 BL5__36 BL5__35 BL5__34 BL5__33
+  BL5__32 BL6_47 BL6_46 BL6_45 BL6_44 BL6_43 BL6_42 BL6_41 BL6_40 BL6_39
+  BL6_38 BL6_37 BL6_36 BL6_35 BL6_34 BL6_33 BL6_32 BL6__47 BL6__46 BL6__45
+  BL6__44 BL6__43 BL6__42 BL6__41 BL6__40 BL6__39 BL6__38 BL6__37 BL6__36
+  BL6__35 BL6__34 BL6__33 BL6__32 BL7_47 BL7_46 BL7_45 BL7_44 BL7_43 BL7_42
+  BL7_41 BL7_40 BL7_39 BL7_38 BL7_37 BL7_36 BL7_35 BL7_34 BL7_33 BL7_32
+  BL7__47 BL7__46 BL7__45 BL7__44 BL7__43 BL7__42 BL7__41 BL7__40 BL7__39
+  BL7__38 BL7__37 BL7__36 BL7__35 BL7__34 BL7__33 BL7__32 BTPCDB DRPRENB
+  DR_0_298 DR_1_284 DR_2_282 DR_3_268 DR_4_266 DR_5_252 DR_6_250 DR_7_236
+  DR_8_234 DR_9_220 DR_10_218 DR_11_204 DR_12_202 DR_13_188 DR_14_186
+  DR_15_172 DR__0_296 DR__1_286 DR__2_280 DR__3_270 DR__4_264 DR__5_254
+  DR__6_248 DR__7_238 DR__8_232 DR__9_222 DR__10_216 DR__11_206 DR__12_200
+  DR__13_190 DR__14_184 DR__15_174 DW_0_294 DW_1_288 DW_2_278 DW_3_272
+  DW_4_262 DW_5_256 DW_6_246 DW_7_240 DW_8_230 DW_9_224 DW_10_214 DW_11_208
+  DW_12_198 DW_13_192 DW_14_182 DW_15_176 DW__0_292 DW__1_290 DW__2_276
+  DW__3_274 DW__4_260 DW__5_258 DW__6_244 DW__7_242 DW__8_228 DW__9_226
+  DW__10_212 DW__11_210 DW__12_196 DW__13_194 DW__14_180 DW__15_178 GDL_47
+  GDL_46 GDL_45 GDL_44 GDL_43 GDL_42 GDL_41 GDL_40 GDL_39 GDL_38 GDL_37
+  GDL_36 GDL_35 GDL_34 GDL_33 GDL_32 GDL__47 GDL__46 GDL__45 GDL__44 GDL__43
+  GDL__42 GDL__41 GDL__40 GDL__39 GDL__38 GDL__37 GDL__36 GDL__35 GDL__34
+  GDL__33 GDL__32 TIELOW_2 YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSS VDD sram_ACDROWLB032T
XLEFTSAROW BTPB BTPSA BTPT BTPWN DR_0_298 DR_1_284 DR_2_282 DR_3_268 DR_4_266
+  DR_5_252 DR_6_250 DR_7_236 DR_8_234 DR_9_220 DR_10_218 DR_11_204 DR_12_202
+  DR_13_188 DR_14_186 DR_15_172 DR__0_296 DR__1_286 DR__2_280 DR__3_270
+  DR__4_264 DR__5_254 DR__6_248 DR__7_238 DR__8_232 DR__9_222 DR__10_216
+  DR__11_206 DR__12_200 DR__13_190 DR__14_184 DR__15_174 DRT_0 DRT_1 DRT_2
+  DRT_3 DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT_10 DRT_11 DRT_12 DRT_13
+  DRT_14 DRT_15 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5 DRT__6 DRT__7
+  DRT__8 DRT__9 DRT__10 DRT__11 DRT__12 DRT__13 DRT__14 DRT__15 DW_0_294
+  DW_1_288 DW_2_278 DW_3_272 DW_4_262 DW_5_256 DW_6_246 DW_7_240 DW_8_230
+  DW_9_224 DW_10_214 DW_11_208 DW_12_198 DW_13_192 DW_14_182 DW_15_176
+  DW__0_292 DW__1_290 DW__2_276 DW__3_274 DW__4_260 DW__5_258 DW__6_244
+  DW__7_242 DW__8_228 DW__9_226 DW__10_212 DW__11_210 DW__12_196 DW__13_194
+  DW__14_180 DW__15_178 GDL_47 GDL_46 GDL_45 GDL_44 GDL_43 GDL_42 GDL_41
+  GDL_40 GDL_39 GDL_38 GDL_37 GDL_36 GDL_35 GDL_34 GDL_33 GDL_32 GDL__47
+  GDL__46 GDL__45 GDL__44 GDL__43 GDL__42 GDL__41 GDL__40 GDL__39 GDL__38
+  GDL__37 GDL__36 GDL__35 GDL__34 GDL__33 GDL__32 GDL_15 GDL_14 GDL_13 GDL_12
+  GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0
+  GDL__15 GDL__14 GDL__13 GDL__12 GDL__11 GDL__10 GDL__9 GDL__8 GDL__7 GDL__6
+  GDL__5 GDL__4 GDL__3 GDL__2 GDL__1 GDL__0 SAEN VSS VDD sram_ABSAROW32LT
XLEFTTOPCDROW BL0_15 BL0_14 BL0_13 BL0_12 BL0_11 BL0_10 BL0_9 BL0_8 BL0_7
+  BL0_6 BL0_5 BL0_4 BL0_3 BL0_2 BL0_1 BL0_0 BL0__15 BL0__14 BL0__13 BL0__12
+  BL0__11 BL0__10 BL0__9 BL0__8 BL0__7 BL0__6 BL0__5 BL0__4 BL0__3 BL0__2
+  BL0__1 BL0__0 BL1_15 BL1_14 BL1_13 BL1_12 BL1_11 BL1_10 BL1_9 BL1_8 BL1_7
+  BL1_6 BL1_5 BL1_4 BL1_3 BL1_2 BL1_1 BL1_0 BL1__15 BL1__14 BL1__13 BL1__12
+  BL1__11 BL1__10 BL1__9 BL1__8 BL1__7 BL1__6 BL1__5 BL1__4 BL1__3 BL1__2
+  BL1__1 BL1__0 BL2_15 BL2_14 BL2_13 BL2_12 BL2_11 BL2_10 BL2_9 BL2_8 BL2_7
+  BL2_6 BL2_5 BL2_4 BL2_3 BL2_2 BL2_1 BL2_0 BL2__15 BL2__14 BL2__13 BL2__12
+  BL2__11 BL2__10 BL2__9 BL2__8 BL2__7 BL2__6 BL2__5 BL2__4 BL2__3 BL2__2
+  BL2__1 BL2__0 BL3_15 BL3_14 BL3_13 BL3_12 BL3_11 BL3_10 BL3_9 BL3_8 BL3_7
+  BL3_6 BL3_5 BL3_4 BL3_3 BL3_2 BL3_1 BL3_0 BL3__15 BL3__14 BL3__13 BL3__12
+  BL3__11 BL3__10 BL3__9 BL3__8 BL3__7 BL3__6 BL3__5 BL3__4 BL3__3 BL3__2
+  BL3__1 BL3__0 BL4_15 BL4_14 BL4_13 BL4_12 BL4_11 BL4_10 BL4_9 BL4_8 BL4_7
+  BL4_6 BL4_5 BL4_4 BL4_3 BL4_2 BL4_1 BL4_0 BL4__15 BL4__14 BL4__13 BL4__12
+  BL4__11 BL4__10 BL4__9 BL4__8 BL4__7 BL4__6 BL4__5 BL4__4 BL4__3 BL4__2
+  BL4__1 BL4__0 BL5_15 BL5_14 BL5_13 BL5_12 BL5_11 BL5_10 BL5_9 BL5_8 BL5_7
+  BL5_6 BL5_5 BL5_4 BL5_3 BL5_2 BL5_1 BL5_0 BL5__15 BL5__14 BL5__13 BL5__12
+  BL5__11 BL5__10 BL5__9 BL5__8 BL5__7 BL5__6 BL5__5 BL5__4 BL5__3 BL5__2
+  BL5__1 BL5__0 BL6_15 BL6_14 BL6_13 BL6_12 BL6_11 BL6_10 BL6_9 BL6_8 BL6_7
+  BL6_6 BL6_5 BL6_4 BL6_3 BL6_2 BL6_1 BL6_0 BL6__15 BL6__14 BL6__13 BL6__12
+  BL6__11 BL6__10 BL6__9 BL6__8 BL6__7 BL6__6 BL6__5 BL6__4 BL6__3 BL6__2
+  BL6__1 BL6__0 BL7_15 BL7_14 BL7_13 BL7_12 BL7_11 BL7_10 BL7_9 BL7_8 BL7_7
+  BL7_6 BL7_5 BL7_4 BL7_3 BL7_2 BL7_1 BL7_0 BL7__15 BL7__14 BL7__13 BL7__12
+  BL7__11 BL7__10 BL7__9 BL7__8 BL7__7 BL7__6 BL7__5 BL7__4 BL7__3 BL7__2
+  BL7__1 BL7__0 BTPCDT DRPRENT DRT_0 DRT_1 DRT_2 DRT_3 DRT_4 DRT_5 DRT_6
+  DRT_7 DRT_8 DRT_9 DRT_10 DRT_11 DRT_12 DRT_13 DRT_14 DRT_15 DRT__0 DRT__1
+  DRT__2 DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8 DRT__9 DRT__10 DRT__11
+  DRT__12 DRT__13 DRT__14 DRT__15 DW_0_294 DW_1_288 DW_2_278 DW_3_272
+  DW_4_262 DW_5_256 DW_6_246 DW_7_240 DW_8_230 DW_9_224 DW_10_214 DW_11_208
+  DW_12_198 DW_13_192 DW_14_182 DW_15_176 DW__0_292 DW__1_290 DW__2_276
+  DW__3_274 DW__4_260 DW__5_258 DW__6_244 DW__7_242 DW__8_228 DW__9_226
+  DW__10_212 DW__11_210 DW__12_196 DW__13_194 DW__14_180 DW__15_178 GDL_15
+  GDL_14 GDL_13 GDL_12 GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4
+  GDL_3 GDL_2 GDL_1 GDL_0 GDL__15 GDL__14 GDL__13 GDL__12 GDL__11 GDL__10
+  GDL__9 GDL__8 GDL__7 GDL__6 GDL__5 GDL__4 GDL__3 GDL__2 GDL__1 GDL__0
+  TIELOW_0 YP0_0N_140 YP0_1N_142 YP0_2N_144 YP0_3N_146 YP0_4N_148 YP0_5N_150
+  YP0_6N_152 YP0_7N_154 VSS VDD sram_ACDROWLT032T
XLOCAL_DEC ATRACK0B ATRACK0T ATRACK1B ATRACK1T ATRACK2B ATRACK2T ATRACK3B
+  ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T AX6NT AY0NB AY0NT AY1NB AY1NT
+  AY2NB AY2NT BS0NT BS1NT BTPB BTPB2_TERM BTPB3_TERM BTPCDB BTP BTPCDT
+  BTP_138 BTPSA BTPSABR BTPSAR BTPSATR BTPT BTPT2_TERM BTPT3_TERM BTPWDB0
+  BTPWDB1 BTPWDT0 BTPWDT1 BTPWN BTPWNR DRPRENB DRPREN DRPRENT DRPREN_156 GTPB
+  GTPDET GTPT LGWEN MBL_TERM MGDLET MGTPE MGTPET VSS VSS RDT RET RRENB RRENT
+  RXP0 RXP1 RXP2 RXP3 SAEN SAENR TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0 XP0_
+  XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ YP0_0N YP0_0N_140 YP0_1N
+  YP0_1N_142 YP0_2N YP0_2N_144 YP0_3N YP0_3N_146 YP0_4N YP0_4N_148 YP0_5N
+  YP0_5N_150 YP0_6N YP0_6N_152 YP0_7N YP0_7N_154 VSS VDD sram_ALOCDECB0BT
XRIGHTBOTCDROW BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56
+  BL0_57 BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0_63 BL0__48 BL0__49 BL0__50
+  BL0__51 BL0__52 BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58 BL0__59
+  BL0__60 BL0__61 BL0__62 BL0__63 BL1_48 BL1_49 BL1_50 BL1_51 BL1_52 BL1_53
+  BL1_54 BL1_55 BL1_56 BL1_57 BL1_58 BL1_59 BL1_60 BL1_61 BL1_62 BL1_63
+  BL1__48 BL1__49 BL1__50 BL1__51 BL1__52 BL1__53 BL1__54 BL1__55 BL1__56
+  BL1__57 BL1__58 BL1__59 BL1__60 BL1__61 BL1__62 BL1__63 BL2_48 BL2_49
+  BL2_50 BL2_51 BL2_52 BL2_53 BL2_54 BL2_55 BL2_56 BL2_57 BL2_58 BL2_59
+  BL2_60 BL2_61 BL2_62 BL2_63 BL2__48 BL2__49 BL2__50 BL2__51 BL2__52 BL2__53
+  BL2__54 BL2__55 BL2__56 BL2__57 BL2__58 BL2__59 BL2__60 BL2__61 BL2__62
+  BL2__63 BL3_48 BL3_49 BL3_50 BL3_51 BL3_52 BL3_53 BL3_54 BL3_55 BL3_56
+  BL3_57 BL3_58 BL3_59 BL3_60 BL3_61 BL3_62 BL3_63 BL3__48 BL3__49 BL3__50
+  BL3__51 BL3__52 BL3__53 BL3__54 BL3__55 BL3__56 BL3__57 BL3__58 BL3__59
+  BL3__60 BL3__61 BL3__62 BL3__63 BL4_48 BL4_49 BL4_50 BL4_51 BL4_52 BL4_53
+  BL4_54 BL4_55 BL4_56 BL4_57 BL4_58 BL4_59 BL4_60 BL4_61 BL4_62 BL4_63
+  BL4__48 BL4__49 BL4__50 BL4__51 BL4__52 BL4__53 BL4__54 BL4__55 BL4__56
+  BL4__57 BL4__58 BL4__59 BL4__60 BL4__61 BL4__62 BL4__63 BL5_48 BL5_49
+  BL5_50 BL5_51 BL5_52 BL5_53 BL5_54 BL5_55 BL5_56 BL5_57 BL5_58 BL5_59
+  BL5_60 BL5_61 BL5_62 BL5_63 BL5__48 BL5__49 BL5__50 BL5__51 BL5__52 BL5__53
+  BL5__54 BL5__55 BL5__56 BL5__57 BL5__58 BL5__59 BL5__60 BL5__61 BL5__62
+  BL5__63 BL6_48 BL6_49 BL6_50 BL6_51 BL6_52 BL6_53 BL6_54 BL6_55 BL6_56
+  BL6_57 BL6_58 BL6_59 BL6_60 BL6_61 BL6_62 BL6_63 BL6__48 BL6__49 BL6__50
+  BL6__51 BL6__52 BL6__53 BL6__54 BL6__55 BL6__56 BL6__57 BL6__58 BL6__59
+  BL6__60 BL6__61 BL6__62 BL6__63 BL7_48 BL7_49 BL7_50 BL7_51 BL7_52 BL7_53
+  BL7_54 BL7_55 BL7_56 BL7_57 BL7_58 BL7_59 BL7_60 BL7_61 BL7_62 BL7_63
+  BL7__48 BL7__49 BL7__50 BL7__51 BL7__52 BL7__53 BL7__54 BL7__55 BL7__56
+  BL7__57 BL7__58 BL7__59 BL7__60 BL7__61 BL7__62 BL7__63 BTP DRPREN DR_0
+  DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7 DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14
+  DR_15 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7 DR__8 DR__9 DR__10
+  DR__11 DR__12 DR__13 DR__14 DR__15 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7
+  DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4
+  DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11 DW__12 DW__13 DW__14 DW__15
+  GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57
+  GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL__48 GDL__49 GDL__50 GDL__51
+  GDL__52 GDL__53 GDL__54 GDL__55 GDL__56 GDL__57 GDL__58 GDL__59 GDL__60
+  GDL__61 GDL__62 GDL__63 TIELOW_3 YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N
+  YP0_6N YP0_7N VSS VDD sram_ACDROWRB032T
XRIGHTBOTSAROW BTPSABR BTPSAR BTPSATR BTPWNR DR_0 DR_1 DR_2 DR_3 DR_4 DR_5
+  DR_6 DR_7 DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2
+  DR__3 DR__4 DR__5 DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13
+  DR__14 DR__15 DR_0_136 DR_1_130 DR_2_128 DR_3_122 DR_4_120 DR_5_114
+  DR_6_112 DR_7_106 DR_8_104 DR_9_98 DR_10_96 DR_11_90 DR_12_88 DR_13_82
+  DR_14_80 DR_15_74 DR__0_134 DR__1_132 DR__2_126 DR__3_124 DR__4_118
+  DR__5_116 DR__6_110 DR__7_108 DR__8_102 DR__9_100 DR__10_94 DR__11_92
+  DR__12_86 DR__13_84 DR__14_78 DR__15_76 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6
+  DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15 DW__0 DW__1 DW__2 DW__3
+  DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11 DW__12 DW__13 DW__14
+  DW__15 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56
+  GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL__48 GDL__49 GDL__50
+  GDL__51 GDL__52 GDL__53 GDL__54 GDL__55 GDL__56 GDL__57 GDL__58 GDL__59
+  GDL__60 GDL__61 GDL__62 GDL__63 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21 GDL__22 GDL__23 GDL__24
+  GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30 GDL__31 SAENR VSS VDD
+  sram_ABSAROW32RT
XRIGHTTOPCDROW BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24
+  BL0_25 BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0__16 BL0__17 BL0__18
+  BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25 BL0__26 BL0__27
+  BL0__28 BL0__29 BL0__30 BL0__31 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21
+  BL1_22 BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31
+  BL1__16 BL1__17 BL1__18 BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24
+  BL1__25 BL1__26 BL1__27 BL1__28 BL1__29 BL1__30 BL1__31 BL2_16 BL2_17
+  BL2_18 BL2_19 BL2_20 BL2_21 BL2_22 BL2_23 BL2_24 BL2_25 BL2_26 BL2_27
+  BL2_28 BL2_29 BL2_30 BL2_31 BL2__16 BL2__17 BL2__18 BL2__19 BL2__20 BL2__21
+  BL2__22 BL2__23 BL2__24 BL2__25 BL2__26 BL2__27 BL2__28 BL2__29 BL2__30
+  BL2__31 BL3_16 BL3_17 BL3_18 BL3_19 BL3_20 BL3_21 BL3_22 BL3_23 BL3_24
+  BL3_25 BL3_26 BL3_27 BL3_28 BL3_29 BL3_30 BL3_31 BL3__16 BL3__17 BL3__18
+  BL3__19 BL3__20 BL3__21 BL3__22 BL3__23 BL3__24 BL3__25 BL3__26 BL3__27
+  BL3__28 BL3__29 BL3__30 BL3__31 BL4_16 BL4_17 BL4_18 BL4_19 BL4_20 BL4_21
+  BL4_22 BL4_23 BL4_24 BL4_25 BL4_26 BL4_27 BL4_28 BL4_29 BL4_30 BL4_31
+  BL4__16 BL4__17 BL4__18 BL4__19 BL4__20 BL4__21 BL4__22 BL4__23 BL4__24
+  BL4__25 BL4__26 BL4__27 BL4__28 BL4__29 BL4__30 BL4__31 BL5_16 BL5_17
+  BL5_18 BL5_19 BL5_20 BL5_21 BL5_22 BL5_23 BL5_24 BL5_25 BL5_26 BL5_27
+  BL5_28 BL5_29 BL5_30 BL5_31 BL5__16 BL5__17 BL5__18 BL5__19 BL5__20 BL5__21
+  BL5__22 BL5__23 BL5__24 BL5__25 BL5__26 BL5__27 BL5__28 BL5__29 BL5__30
+  BL5__31 BL6_16 BL6_17 BL6_18 BL6_19 BL6_20 BL6_21 BL6_22 BL6_23 BL6_24
+  BL6_25 BL6_26 BL6_27 BL6_28 BL6_29 BL6_30 BL6_31 BL6__16 BL6__17 BL6__18
+  BL6__19 BL6__20 BL6__21 BL6__22 BL6__23 BL6__24 BL6__25 BL6__26 BL6__27
+  BL6__28 BL6__29 BL6__30 BL6__31 BL7_16 BL7_17 BL7_18 BL7_19 BL7_20 BL7_21
+  BL7_22 BL7_23 BL7_24 BL7_25 BL7_26 BL7_27 BL7_28 BL7_29 BL7_30 BL7_31
+  BL7__16 BL7__17 BL7__18 BL7__19 BL7__20 BL7__21 BL7__22 BL7__23 BL7__24
+  BL7__25 BL7__26 BL7__27 BL7__28 BL7__29 BL7__30 BL7__31 BTP_138 DRPREN_156
+  DR_0_136 DR_1_130 DR_2_128 DR_3_122 DR_4_120 DR_5_114 DR_6_112 DR_7_106
+  DR_8_104 DR_9_98 DR_10_96 DR_11_90 DR_12_88 DR_13_82 DR_14_80 DR_15_74
+  DR__0_134 DR__1_132 DR__2_126 DR__3_124 DR__4_118 DR__5_116 DR__6_110
+  DR__7_108 DR__8_102 DR__9_100 DR__10_94 DR__11_92 DR__12_86 DR__13_84
+  DR__14_78 DR__15_76 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10
+  DW_11 DW_12 DW_13 DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6
+  DW__7 DW__8 DW__9 DW__10 DW__11 DW__12 DW__13 DW__14 DW__15 GDL_16 GDL_17
+  GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27
+  GDL_28 GDL_29 GDL_30 GDL_31 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21
+  GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30
+  GDL__31 TIELOW_1 YP0_0N_140 YP0_1N_142 YP0_2N_144 YP0_3N_146 YP0_4N_148
+  YP0_5N_150 YP0_6N_152 YP0_7N_154 VSS VDD sram_ACDROWRT032T
.ENDS sram_ACHB0_32M8BT
****
.SUBCKT sram_ACC BL BL_ CORED CORED_ GDL PG0 WL VSS VDD
** sram_ACC: 6 flat devices **
M0 CORED CORED_ VDD VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDD CORED CORED_ VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 CORED_ CORED VSS VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M3 VSS CORED_ CORED VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M4 BL WL CORED VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL BL_ VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS sram_ACC
****
.SUBCKT sram_AWRAPPED_CC BL BL_ GDL PG0 WL VSS VDD
** sram_AWRAPPED_CC: 6 flat devices **
XI0 BL BL_ CORED CORED_ GDL PG0 WL VSS VDD sram_ACC
.ENDS sram_AWRAPPED_CC
****
.SUBCKT sram_ACCEDGE_CCMBL BL CCMBL DIFF GDL NDIFF PDIFF PG0 TL0 WL VSS VDD
** sram_ACCEDGE_CCMBL: 6 flat devices **
M0 NET41 NET49 VSS VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M1 NDIFF NET41 NET49 VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M2 NET41 WL DIFF VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
M3 CCMBL TL0 NET49 VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M4 PDIFF NET49 NET41 VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M5 NET49 NET41 VDD VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
.ENDS sram_ACCEDGE_CCMBL
****
.SUBCKT sram_ACC_ROW128LO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21
+  BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33
+  BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45
+  BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57
+  BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69
+  BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81
+  BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93
+  BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104
+  BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124
+  BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7
+  GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18
+  GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28
+  GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38
+  GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48
+  GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58
+  GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68
+  GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78
+  GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88
+  GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98
+  GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107
+  GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116
+  GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125
+  GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46
+  PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56
+  PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66
+  PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76
+  PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86
+  PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96
+  PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105
+  PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114
+  PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123
+  PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL VSS VDD
** sram_ACC_ROW128LO: 774 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSS VDD sram_AWRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSS VDD sram_AWRAPPED_CC
XCC100 BL_100 BL__99 GDL_100 PG0_100 WL VSS VDD sram_AWRAPPED_CC
XCC101 BL_101 BL__100 GDL_101 PG0_101 WL VSS VDD sram_AWRAPPED_CC
XCC102 BL_102 BL__101 GDL_102 PG0_102 WL VSS VDD sram_AWRAPPED_CC
XCC103 BL_103 BL__102 GDL_103 PG0_103 WL VSS VDD sram_AWRAPPED_CC
XCC104 BL_104 BL__103 GDL_104 PG0_104 WL VSS VDD sram_AWRAPPED_CC
XCC105 BL_105 BL__104 GDL_105 PG0_105 WL VSS VDD sram_AWRAPPED_CC
XCC106 BL_106 BL__105 GDL_106 PG0_106 WL VSS VDD sram_AWRAPPED_CC
XCC107 BL_107 BL__106 GDL_107 PG0_107 WL VSS VDD sram_AWRAPPED_CC
XCC108 BL_108 BL__107 GDL_108 PG0_108 WL VSS VDD sram_AWRAPPED_CC
XCC109 BL_109 BL__108 GDL_109 PG0_109 WL VSS VDD sram_AWRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSS VDD sram_AWRAPPED_CC
XCC110 BL_110 BL__109 GDL_110 PG0_110 WL VSS VDD sram_AWRAPPED_CC
XCC111 BL_111 BL__110 GDL_111 PG0_111 WL VSS VDD sram_AWRAPPED_CC
XCC112 BL_112 BL__111 GDL_112 PG0_112 WL VSS VDD sram_AWRAPPED_CC
XCC113 BL_113 BL__112 GDL_113 PG0_113 WL VSS VDD sram_AWRAPPED_CC
XCC114 BL_114 BL__113 GDL_114 PG0_114 WL VSS VDD sram_AWRAPPED_CC
XCC115 BL_115 BL__114 GDL_115 PG0_115 WL VSS VDD sram_AWRAPPED_CC
XCC116 BL_116 BL__115 GDL_116 PG0_116 WL VSS VDD sram_AWRAPPED_CC
XCC117 BL_117 BL__116 GDL_117 PG0_117 WL VSS VDD sram_AWRAPPED_CC
XCC118 BL_118 BL__117 GDL_118 PG0_118 WL VSS VDD sram_AWRAPPED_CC
XCC119 BL_119 BL__118 GDL_119 PG0_119 WL VSS VDD sram_AWRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSS VDD sram_AWRAPPED_CC
XCC120 BL_120 BL__119 GDL_120 PG0_120 WL VSS VDD sram_AWRAPPED_CC
XCC121 BL_121 BL__120 GDL_121 PG0_121 WL VSS VDD sram_AWRAPPED_CC
XCC122 BL_122 BL__121 GDL_122 PG0_122 WL VSS VDD sram_AWRAPPED_CC
XCC123 BL_123 BL__122 GDL_123 PG0_123 WL VSS VDD sram_AWRAPPED_CC
XCC124 BL_124 BL__123 GDL_124 PG0_124 WL VSS VDD sram_AWRAPPED_CC
XCC125 BL_125 BL__124 GDL_125 PG0_125 WL VSS VDD sram_AWRAPPED_CC
XCC126 BL_126 BL__125 GDL_126 PG0_126 WL VSS VDD sram_AWRAPPED_CC
XCC127 BL_127 BL__126 GDL_127 PG0_127 WL VSS VDD sram_AWRAPPED_CC
XCC128 BL_128 BL__127 GDL_128 PG0_128 WL VSS VDD sram_AWRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSS VDD sram_AWRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSS VDD sram_AWRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSS VDD sram_AWRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSS VDD sram_AWRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSS VDD sram_AWRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSS VDD sram_AWRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSS VDD sram_AWRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSS VDD sram_AWRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSS VDD sram_AWRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSS VDD sram_AWRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSS VDD sram_AWRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSS VDD sram_AWRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSS VDD sram_AWRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSS VDD sram_AWRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSS VDD sram_AWRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSS VDD sram_AWRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSS VDD sram_AWRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSS VDD sram_AWRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSS VDD sram_AWRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSS VDD sram_AWRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSS VDD sram_AWRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSS VDD sram_AWRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSS VDD sram_AWRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSS VDD sram_AWRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSS VDD sram_AWRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSS VDD sram_AWRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSS VDD sram_AWRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSS VDD sram_AWRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSS VDD sram_AWRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSS VDD sram_AWRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSS VDD sram_AWRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSS VDD sram_AWRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSS VDD sram_AWRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSS VDD sram_AWRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSS VDD sram_AWRAPPED_CC
XCC45 BL_45 BL__44 GDL_45 PG0_45 WL VSS VDD sram_AWRAPPED_CC
XCC46 BL_46 BL__45 GDL_46 PG0_46 WL VSS VDD sram_AWRAPPED_CC
XCC47 BL_47 BL__46 GDL_47 PG0_47 WL VSS VDD sram_AWRAPPED_CC
XCC48 BL_48 BL__47 GDL_48 PG0_48 WL VSS VDD sram_AWRAPPED_CC
XCC49 BL_49 BL__48 GDL_49 PG0_49 WL VSS VDD sram_AWRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSS VDD sram_AWRAPPED_CC
XCC50 BL_50 BL__49 GDL_50 PG0_50 WL VSS VDD sram_AWRAPPED_CC
XCC51 BL_51 BL__50 GDL_51 PG0_51 WL VSS VDD sram_AWRAPPED_CC
XCC52 BL_52 BL__51 GDL_52 PG0_52 WL VSS VDD sram_AWRAPPED_CC
XCC53 BL_53 BL__52 GDL_53 PG0_53 WL VSS VDD sram_AWRAPPED_CC
XCC54 BL_54 BL__53 GDL_54 PG0_54 WL VSS VDD sram_AWRAPPED_CC
XCC55 BL_55 BL__54 GDL_55 PG0_55 WL VSS VDD sram_AWRAPPED_CC
XCC56 BL_56 BL__55 GDL_56 PG0_56 WL VSS VDD sram_AWRAPPED_CC
XCC57 BL_57 BL__56 GDL_57 PG0_57 WL VSS VDD sram_AWRAPPED_CC
XCC58 BL_58 BL__57 GDL_58 PG0_58 WL VSS VDD sram_AWRAPPED_CC
XCC59 BL_59 BL__58 GDL_59 PG0_59 WL VSS VDD sram_AWRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSS VDD sram_AWRAPPED_CC
XCC60 BL_60 BL__59 GDL_60 PG0_60 WL VSS VDD sram_AWRAPPED_CC
XCC61 BL_61 BL__60 GDL_61 PG0_61 WL VSS VDD sram_AWRAPPED_CC
XCC62 BL_62 BL__61 GDL_62 PG0_62 WL VSS VDD sram_AWRAPPED_CC
XCC63 BL_63 BL__62 GDL_63 PG0_63 WL VSS VDD sram_AWRAPPED_CC
XCC64 BL_64 BL__63 GDL_64 PG0_64 WL VSS VDD sram_AWRAPPED_CC
XCC65 BL_65 BL__64 GDL_65 PG0_65 WL VSS VDD sram_AWRAPPED_CC
XCC66 BL_66 BL__65 GDL_66 PG0_66 WL VSS VDD sram_AWRAPPED_CC
XCC67 BL_67 BL__66 GDL_67 PG0_67 WL VSS VDD sram_AWRAPPED_CC
XCC68 BL_68 BL__67 GDL_68 PG0_68 WL VSS VDD sram_AWRAPPED_CC
XCC69 BL_69 BL__68 GDL_69 PG0_69 WL VSS VDD sram_AWRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSS VDD sram_AWRAPPED_CC
XCC70 BL_70 BL__69 GDL_70 PG0_70 WL VSS VDD sram_AWRAPPED_CC
XCC71 BL_71 BL__70 GDL_71 PG0_71 WL VSS VDD sram_AWRAPPED_CC
XCC72 BL_72 BL__71 GDL_72 PG0_72 WL VSS VDD sram_AWRAPPED_CC
XCC73 BL_73 BL__72 GDL_73 PG0_73 WL VSS VDD sram_AWRAPPED_CC
XCC74 BL_74 BL__73 GDL_74 PG0_74 WL VSS VDD sram_AWRAPPED_CC
XCC75 BL_75 BL__74 GDL_75 PG0_75 WL VSS VDD sram_AWRAPPED_CC
XCC76 BL_76 BL__75 GDL_76 PG0_76 WL VSS VDD sram_AWRAPPED_CC
XCC77 BL_77 BL__76 GDL_77 PG0_77 WL VSS VDD sram_AWRAPPED_CC
XCC78 BL_78 BL__77 GDL_78 PG0_78 WL VSS VDD sram_AWRAPPED_CC
XCC79 BL_79 BL__78 GDL_79 PG0_79 WL VSS VDD sram_AWRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSS VDD sram_AWRAPPED_CC
XCC80 BL_80 BL__79 GDL_80 PG0_80 WL VSS VDD sram_AWRAPPED_CC
XCC81 BL_81 BL__80 GDL_81 PG0_81 WL VSS VDD sram_AWRAPPED_CC
XCC82 BL_82 BL__81 GDL_82 PG0_82 WL VSS VDD sram_AWRAPPED_CC
XCC83 BL_83 BL__82 GDL_83 PG0_83 WL VSS VDD sram_AWRAPPED_CC
XCC84 BL_84 BL__83 GDL_84 PG0_84 WL VSS VDD sram_AWRAPPED_CC
XCC85 BL_85 BL__84 GDL_85 PG0_85 WL VSS VDD sram_AWRAPPED_CC
XCC86 BL_86 BL__85 GDL_86 PG0_86 WL VSS VDD sram_AWRAPPED_CC
XCC87 BL_87 BL__86 GDL_87 PG0_87 WL VSS VDD sram_AWRAPPED_CC
XCC88 BL_88 BL__87 GDL_88 PG0_88 WL VSS VDD sram_AWRAPPED_CC
XCC89 BL_89 BL__88 GDL_89 PG0_89 WL VSS VDD sram_AWRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSS VDD sram_AWRAPPED_CC
XCC90 BL_90 BL__89 GDL_90 PG0_90 WL VSS VDD sram_AWRAPPED_CC
XCC91 BL_91 BL__90 GDL_91 PG0_91 WL VSS VDD sram_AWRAPPED_CC
XCC92 BL_92 BL__91 GDL_92 PG0_92 WL VSS VDD sram_AWRAPPED_CC
XCC93 BL_93 BL__92 GDL_93 PG0_93 WL VSS VDD sram_AWRAPPED_CC
XCC94 BL_94 BL__93 GDL_94 PG0_94 WL VSS VDD sram_AWRAPPED_CC
XCC95 BL_95 BL__94 GDL_95 PG0_95 WL VSS VDD sram_AWRAPPED_CC
XCC96 BL_96 BL__95 GDL_96 PG0_96 WL VSS VDD sram_AWRAPPED_CC
XCC97 BL_97 BL__96 GDL_97 PG0_97 WL VSS VDD sram_AWRAPPED_CC
XCC98 BL_98 BL__97 GDL_98 PG0_98 WL VSS VDD sram_AWRAPPED_CC
XCC99 BL_99 BL__98 GDL_99 PG0_99 WL VSS VDD sram_AWRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSS VDD
+  sram_ACCEDGE_CCMBL
.ENDS sram_ACC_ROW128LO
****
.SUBCKT sram_ACC_ROW128LE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21
+  BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33
+  BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45
+  BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57
+  BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69
+  BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81
+  BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93
+  BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104
+  BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124
+  BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7
+  GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18
+  GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28
+  GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38
+  GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48
+  GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58
+  GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68
+  GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78
+  GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88
+  GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98
+  GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107
+  GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116
+  GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125
+  GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46
+  PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56
+  PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66
+  PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76
+  PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86
+  PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96
+  PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105
+  PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114
+  PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123
+  PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL VSS VDD
** sram_ACC_ROW128LE: 774 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSS VDD sram_AWRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSS VDD sram_AWRAPPED_CC
XCC100 BL_100 BL__99 GDL_100 PG0_100 WL VSS VDD sram_AWRAPPED_CC
XCC101 BL_101 BL__100 GDL_101 PG0_101 WL VSS VDD sram_AWRAPPED_CC
XCC102 BL_102 BL__101 GDL_102 PG0_102 WL VSS VDD sram_AWRAPPED_CC
XCC103 BL_103 BL__102 GDL_103 PG0_103 WL VSS VDD sram_AWRAPPED_CC
XCC104 BL_104 BL__103 GDL_104 PG0_104 WL VSS VDD sram_AWRAPPED_CC
XCC105 BL_105 BL__104 GDL_105 PG0_105 WL VSS VDD sram_AWRAPPED_CC
XCC106 BL_106 BL__105 GDL_106 PG0_106 WL VSS VDD sram_AWRAPPED_CC
XCC107 BL_107 BL__106 GDL_107 PG0_107 WL VSS VDD sram_AWRAPPED_CC
XCC108 BL_108 BL__107 GDL_108 PG0_108 WL VSS VDD sram_AWRAPPED_CC
XCC109 BL_109 BL__108 GDL_109 PG0_109 WL VSS VDD sram_AWRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSS VDD sram_AWRAPPED_CC
XCC110 BL_110 BL__109 GDL_110 PG0_110 WL VSS VDD sram_AWRAPPED_CC
XCC111 BL_111 BL__110 GDL_111 PG0_111 WL VSS VDD sram_AWRAPPED_CC
XCC112 BL_112 BL__111 GDL_112 PG0_112 WL VSS VDD sram_AWRAPPED_CC
XCC113 BL_113 BL__112 GDL_113 PG0_113 WL VSS VDD sram_AWRAPPED_CC
XCC114 BL_114 BL__113 GDL_114 PG0_114 WL VSS VDD sram_AWRAPPED_CC
XCC115 BL_115 BL__114 GDL_115 PG0_115 WL VSS VDD sram_AWRAPPED_CC
XCC116 BL_116 BL__115 GDL_116 PG0_116 WL VSS VDD sram_AWRAPPED_CC
XCC117 BL_117 BL__116 GDL_117 PG0_117 WL VSS VDD sram_AWRAPPED_CC
XCC118 BL_118 BL__117 GDL_118 PG0_118 WL VSS VDD sram_AWRAPPED_CC
XCC119 BL_119 BL__118 GDL_119 PG0_119 WL VSS VDD sram_AWRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSS VDD sram_AWRAPPED_CC
XCC120 BL_120 BL__119 GDL_120 PG0_120 WL VSS VDD sram_AWRAPPED_CC
XCC121 BL_121 BL__120 GDL_121 PG0_121 WL VSS VDD sram_AWRAPPED_CC
XCC122 BL_122 BL__121 GDL_122 PG0_122 WL VSS VDD sram_AWRAPPED_CC
XCC123 BL_123 BL__122 GDL_123 PG0_123 WL VSS VDD sram_AWRAPPED_CC
XCC124 BL_124 BL__123 GDL_124 PG0_124 WL VSS VDD sram_AWRAPPED_CC
XCC125 BL_125 BL__124 GDL_125 PG0_125 WL VSS VDD sram_AWRAPPED_CC
XCC126 BL_126 BL__125 GDL_126 PG0_126 WL VSS VDD sram_AWRAPPED_CC
XCC127 BL_127 BL__126 GDL_127 PG0_127 WL VSS VDD sram_AWRAPPED_CC
XCC128 BL_128 BL__127 GDL_128 PG0_128 WL VSS VDD sram_AWRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSS VDD sram_AWRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSS VDD sram_AWRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSS VDD sram_AWRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSS VDD sram_AWRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSS VDD sram_AWRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSS VDD sram_AWRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSS VDD sram_AWRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSS VDD sram_AWRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSS VDD sram_AWRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSS VDD sram_AWRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSS VDD sram_AWRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSS VDD sram_AWRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSS VDD sram_AWRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSS VDD sram_AWRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSS VDD sram_AWRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSS VDD sram_AWRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSS VDD sram_AWRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSS VDD sram_AWRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSS VDD sram_AWRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSS VDD sram_AWRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSS VDD sram_AWRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSS VDD sram_AWRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSS VDD sram_AWRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSS VDD sram_AWRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSS VDD sram_AWRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSS VDD sram_AWRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSS VDD sram_AWRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSS VDD sram_AWRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSS VDD sram_AWRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSS VDD sram_AWRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSS VDD sram_AWRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSS VDD sram_AWRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSS VDD sram_AWRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSS VDD sram_AWRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSS VDD sram_AWRAPPED_CC
XCC45 BL_45 BL__44 GDL_45 PG0_45 WL VSS VDD sram_AWRAPPED_CC
XCC46 BL_46 BL__45 GDL_46 PG0_46 WL VSS VDD sram_AWRAPPED_CC
XCC47 BL_47 BL__46 GDL_47 PG0_47 WL VSS VDD sram_AWRAPPED_CC
XCC48 BL_48 BL__47 GDL_48 PG0_48 WL VSS VDD sram_AWRAPPED_CC
XCC49 BL_49 BL__48 GDL_49 PG0_49 WL VSS VDD sram_AWRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSS VDD sram_AWRAPPED_CC
XCC50 BL_50 BL__49 GDL_50 PG0_50 WL VSS VDD sram_AWRAPPED_CC
XCC51 BL_51 BL__50 GDL_51 PG0_51 WL VSS VDD sram_AWRAPPED_CC
XCC52 BL_52 BL__51 GDL_52 PG0_52 WL VSS VDD sram_AWRAPPED_CC
XCC53 BL_53 BL__52 GDL_53 PG0_53 WL VSS VDD sram_AWRAPPED_CC
XCC54 BL_54 BL__53 GDL_54 PG0_54 WL VSS VDD sram_AWRAPPED_CC
XCC55 BL_55 BL__54 GDL_55 PG0_55 WL VSS VDD sram_AWRAPPED_CC
XCC56 BL_56 BL__55 GDL_56 PG0_56 WL VSS VDD sram_AWRAPPED_CC
XCC57 BL_57 BL__56 GDL_57 PG0_57 WL VSS VDD sram_AWRAPPED_CC
XCC58 BL_58 BL__57 GDL_58 PG0_58 WL VSS VDD sram_AWRAPPED_CC
XCC59 BL_59 BL__58 GDL_59 PG0_59 WL VSS VDD sram_AWRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSS VDD sram_AWRAPPED_CC
XCC60 BL_60 BL__59 GDL_60 PG0_60 WL VSS VDD sram_AWRAPPED_CC
XCC61 BL_61 BL__60 GDL_61 PG0_61 WL VSS VDD sram_AWRAPPED_CC
XCC62 BL_62 BL__61 GDL_62 PG0_62 WL VSS VDD sram_AWRAPPED_CC
XCC63 BL_63 BL__62 GDL_63 PG0_63 WL VSS VDD sram_AWRAPPED_CC
XCC64 BL_64 BL__63 GDL_64 PG0_64 WL VSS VDD sram_AWRAPPED_CC
XCC65 BL_65 BL__64 GDL_65 PG0_65 WL VSS VDD sram_AWRAPPED_CC
XCC66 BL_66 BL__65 GDL_66 PG0_66 WL VSS VDD sram_AWRAPPED_CC
XCC67 BL_67 BL__66 GDL_67 PG0_67 WL VSS VDD sram_AWRAPPED_CC
XCC68 BL_68 BL__67 GDL_68 PG0_68 WL VSS VDD sram_AWRAPPED_CC
XCC69 BL_69 BL__68 GDL_69 PG0_69 WL VSS VDD sram_AWRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSS VDD sram_AWRAPPED_CC
XCC70 BL_70 BL__69 GDL_70 PG0_70 WL VSS VDD sram_AWRAPPED_CC
XCC71 BL_71 BL__70 GDL_71 PG0_71 WL VSS VDD sram_AWRAPPED_CC
XCC72 BL_72 BL__71 GDL_72 PG0_72 WL VSS VDD sram_AWRAPPED_CC
XCC73 BL_73 BL__72 GDL_73 PG0_73 WL VSS VDD sram_AWRAPPED_CC
XCC74 BL_74 BL__73 GDL_74 PG0_74 WL VSS VDD sram_AWRAPPED_CC
XCC75 BL_75 BL__74 GDL_75 PG0_75 WL VSS VDD sram_AWRAPPED_CC
XCC76 BL_76 BL__75 GDL_76 PG0_76 WL VSS VDD sram_AWRAPPED_CC
XCC77 BL_77 BL__76 GDL_77 PG0_77 WL VSS VDD sram_AWRAPPED_CC
XCC78 BL_78 BL__77 GDL_78 PG0_78 WL VSS VDD sram_AWRAPPED_CC
XCC79 BL_79 BL__78 GDL_79 PG0_79 WL VSS VDD sram_AWRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSS VDD sram_AWRAPPED_CC
XCC80 BL_80 BL__79 GDL_80 PG0_80 WL VSS VDD sram_AWRAPPED_CC
XCC81 BL_81 BL__80 GDL_81 PG0_81 WL VSS VDD sram_AWRAPPED_CC
XCC82 BL_82 BL__81 GDL_82 PG0_82 WL VSS VDD sram_AWRAPPED_CC
XCC83 BL_83 BL__82 GDL_83 PG0_83 WL VSS VDD sram_AWRAPPED_CC
XCC84 BL_84 BL__83 GDL_84 PG0_84 WL VSS VDD sram_AWRAPPED_CC
XCC85 BL_85 BL__84 GDL_85 PG0_85 WL VSS VDD sram_AWRAPPED_CC
XCC86 BL_86 BL__85 GDL_86 PG0_86 WL VSS VDD sram_AWRAPPED_CC
XCC87 BL_87 BL__86 GDL_87 PG0_87 WL VSS VDD sram_AWRAPPED_CC
XCC88 BL_88 BL__87 GDL_88 PG0_88 WL VSS VDD sram_AWRAPPED_CC
XCC89 BL_89 BL__88 GDL_89 PG0_89 WL VSS VDD sram_AWRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSS VDD sram_AWRAPPED_CC
XCC90 BL_90 BL__89 GDL_90 PG0_90 WL VSS VDD sram_AWRAPPED_CC
XCC91 BL_91 BL__90 GDL_91 PG0_91 WL VSS VDD sram_AWRAPPED_CC
XCC92 BL_92 BL__91 GDL_92 PG0_92 WL VSS VDD sram_AWRAPPED_CC
XCC93 BL_93 BL__92 GDL_93 PG0_93 WL VSS VDD sram_AWRAPPED_CC
XCC94 BL_94 BL__93 GDL_94 PG0_94 WL VSS VDD sram_AWRAPPED_CC
XCC95 BL_95 BL__94 GDL_95 PG0_95 WL VSS VDD sram_AWRAPPED_CC
XCC96 BL_96 BL__95 GDL_96 PG0_96 WL VSS VDD sram_AWRAPPED_CC
XCC97 BL_97 BL__96 GDL_97 PG0_97 WL VSS VDD sram_AWRAPPED_CC
XCC98 BL_98 BL__97 GDL_98 PG0_98 WL VSS VDD sram_AWRAPPED_CC
XCC99 BL_99 BL__98 GDL_99 PG0_99 WL VSS VDD sram_AWRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSS VDD
+  sram_ACCEDGE_CCMBL
.ENDS sram_ACC_ROW128LE
****
.SUBCKT sram_ACCW BL BL_ CORED CORED_ DIFF1 DIFF2 GDL PG0 WL VSS VDD
** sram_ACCW: 6 flat devices **
M0 CORED CORED_ VDD VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDD CORED CORED_ VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 CORED_ CORED VSS VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M3 VSS CORED_ CORED VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M4 DIFF1 WL CORED VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL DIFF2 VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS sram_ACCW
****
.SUBCKT sram_AMWL_CC BL BL_ DIFF1 DIFF2 GDL PG0 WL VSS VDD
** sram_AMWL_CC: 6 flat devices **
XI0 BL BL_ CORED CORED_ DIFF1 DIFF2 GDL PG0 WL VSS VDD sram_ACCW
.ENDS sram_AMWL_CC
****
.SUBCKT sram_AFLMW BL BL_ DIFF1 DIFF2 GDL PG0 WL0 WL1 VSS VDD
** sram_AFLMW: 6 flat devices **
M0 VSS CORED_ CORED VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M1 CORED_ CORED VSS VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M2 VDD CORED CORED_ VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M3 CORED CORED_ VDD VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M4 DIFF1 WL0 CORED VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL1 DIFF2 VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS sram_AFLMW
****
.SUBCKT sram_AMWL_ROW128LO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21
+  BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33
+  BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45
+  BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57
+  BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69
+  BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81
+  BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93
+  BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104
+  BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124
+  BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5
+  DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13
+  DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21
+  DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29
+  DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37
+  DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44 DIFF1_45
+  DIFF1_46 DIFF1_47 DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52 DIFF1_53
+  DIFF1_54 DIFF1_55 DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60 DIFF1_61
+  DIFF1_62 DIFF1_63 DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68 DIFF1_69
+  DIFF1_70 DIFF1_71 DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76 DIFF1_77
+  DIFF1_78 DIFF1_79 DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84 DIFF1_85
+  DIFF1_86 DIFF1_87 DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92 DIFF1_93
+  DIFF1_94 DIFF1_95 DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100 DIFF1_101
+  DIFF1_102 DIFF1_103 DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107 DIFF1_108
+  DIFF1_109 DIFF1_110 DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114 DIFF1_115
+  DIFF1_116 DIFF1_117 DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121 DIFF1_122
+  DIFF1_123 DIFF1_124 DIFF1_125 DIFF1_126 DIFF1_127 DIFF2_0 DIFF2_1 DIFF2_2
+  DIFF2_3 DIFF2_4 DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11
+  DIFF2_12 DIFF2_13 DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19
+  DIFF2_20 DIFF2_21 DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27
+  DIFF2_28 DIFF2_29 DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35
+  DIFF2_36 DIFF2_37 DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42 DIFF2_43
+  DIFF2_44 DIFF2_45 DIFF2_46 DIFF2_47 DIFF2_48 DIFF2_49 DIFF2_50 DIFF2_51
+  DIFF2_52 DIFF2_53 DIFF2_54 DIFF2_55 DIFF2_56 DIFF2_57 DIFF2_58 DIFF2_59
+  DIFF2_60 DIFF2_61 DIFF2_62 DIFF2_63 DIFF2_64 DIFF2_65 DIFF2_66 DIFF2_67
+  DIFF2_68 DIFF2_69 DIFF2_70 DIFF2_71 DIFF2_72 DIFF2_73 DIFF2_74 DIFF2_75
+  DIFF2_76 DIFF2_77 DIFF2_78 DIFF2_79 DIFF2_80 DIFF2_81 DIFF2_82 DIFF2_83
+  DIFF2_84 DIFF2_85 DIFF2_86 DIFF2_87 DIFF2_88 DIFF2_89 DIFF2_90 DIFF2_91
+  DIFF2_92 DIFF2_93 DIFF2_94 DIFF2_95 DIFF2_96 DIFF2_97 DIFF2_98 DIFF2_99
+  DIFF2_100 DIFF2_101 DIFF2_102 DIFF2_103 DIFF2_104 DIFF2_105 DIFF2_106
+  DIFF2_107 DIFF2_108 DIFF2_109 DIFF2_110 DIFF2_111 DIFF2_112 DIFF2_113
+  DIFF2_114 DIFF2_115 DIFF2_116 DIFF2_117 DIFF2_118 DIFF2_119 DIFF2_120
+  DIFF2_121 DIFF2_122 DIFF2_123 DIFF2_124 DIFF2_125 DIFF2_126 DIFF2_127 GDL_0
+  GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12
+  GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22
+  GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32
+  GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42
+  GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52
+  GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62
+  GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72
+  GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82
+  GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92
+  GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102
+  GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111
+  GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120
+  GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF
+  PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11
+  PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21
+  PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31
+  PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41
+  PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51
+  PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61
+  PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71
+  PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81
+  PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91
+  PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101
+  PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110
+  PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119
+  PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128
+  TL0_0 TL0_1 TL1 WL1 VSS VDD
** sram_AMWL_ROW128LO: 774 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 DIFF2_0 GDL_1 PG0_1 WL1 VSS VDD sram_AMWL_CC
XCC10 BL_10 BL__9 DIFF1_9 DIFF2_9 GDL_10 PG0_10 WL1 VSS VDD sram_AMWL_CC
XCC100 BL_100 BL__99 DIFF1_99 DIFF2_99 GDL_100 PG0_100 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC101 BL_101 BL__100 DIFF1_100 DIFF2_100 GDL_101 PG0_101 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC102 BL_102 BL__101 DIFF1_101 DIFF2_101 GDL_102 PG0_102 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC103 BL_103 BL__102 DIFF1_102 DIFF2_102 GDL_103 PG0_103 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC104 BL_104 BL__103 DIFF1_103 DIFF2_103 GDL_104 PG0_104 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC105 BL_105 BL__104 DIFF1_104 DIFF2_104 GDL_105 PG0_105 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC106 BL_106 BL__105 DIFF1_105 DIFF2_105 GDL_106 PG0_106 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC107 BL_107 BL__106 DIFF1_106 DIFF2_106 GDL_107 PG0_107 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC108 BL_108 BL__107 DIFF1_107 DIFF2_107 GDL_108 PG0_108 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC109 BL_109 BL__108 DIFF1_108 DIFF2_108 GDL_109 PG0_109 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC11 BL_11 BL__10 DIFF1_10 DIFF2_10 GDL_11 PG0_11 WL1 VSS VDD sram_AMWL_CC
XCC110 BL_110 BL__109 DIFF1_109 DIFF2_109 GDL_110 PG0_110 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC111 BL_111 BL__110 DIFF1_110 DIFF2_110 GDL_111 PG0_111 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC112 BL_112 BL__111 DIFF1_111 DIFF2_111 GDL_112 PG0_112 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC113 BL_113 BL__112 DIFF1_112 DIFF2_112 GDL_113 PG0_113 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC114 BL_114 BL__113 DIFF1_113 DIFF2_113 GDL_114 PG0_114 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC115 BL_115 BL__114 DIFF1_114 DIFF2_114 GDL_115 PG0_115 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC116 BL_116 BL__115 DIFF1_115 DIFF2_115 GDL_116 PG0_116 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC117 BL_117 BL__116 DIFF1_116 DIFF2_116 GDL_117 PG0_117 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC118 BL_118 BL__117 DIFF1_117 DIFF2_117 GDL_118 PG0_118 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC119 BL_119 BL__118 DIFF1_118 DIFF2_118 GDL_119 PG0_119 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC12 BL_12 BL__11 DIFF1_11 DIFF2_11 GDL_12 PG0_12 WL1 VSS VDD sram_AMWL_CC
XCC120 BL_120 BL__119 DIFF1_119 DIFF2_119 GDL_120 PG0_120 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC121 BL_121 BL__120 DIFF1_120 DIFF2_120 GDL_121 PG0_121 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC122 BL_122 BL__121 DIFF1_121 DIFF2_121 GDL_122 PG0_122 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC123 BL_123 BL__122 DIFF1_122 DIFF2_122 GDL_123 PG0_123 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC124 BL_124 BL__123 DIFF1_123 DIFF2_123 GDL_124 PG0_124 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC125 BL_125 BL__124 DIFF1_124 DIFF2_124 GDL_125 PG0_125 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC126 BL_126 BL__125 DIFF1_125 DIFF2_125 GDL_126 PG0_126 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC127 BL_127 BL__126 DIFF1_126 DIFF2_126 GDL_127 PG0_127 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC128 BL_128 BL__127 DIFF1_127 DIFF2_127 GDL_128 PG0_128 TL0_1 VSS VDD
+  sram_AMWL_CC
XCC13 BL_13 BL__12 DIFF1_12 DIFF2_12 GDL_13 PG0_13 WL1 VSS VDD sram_AMWL_CC
XCC14 BL_14 BL__13 DIFF1_13 DIFF2_13 GDL_14 PG0_14 WL1 VSS VDD sram_AMWL_CC
XCC15 BL_15 BL__14 DIFF1_14 DIFF2_14 GDL_15 PG0_15 WL1 VSS VDD sram_AMWL_CC
XCC16 BL_16 BL__15 DIFF1_15 DIFF2_15 GDL_16 PG0_16 WL1 VSS VDD sram_AMWL_CC
XCC17 BL_17 BL__16 DIFF1_16 DIFF2_16 GDL_17 PG0_17 WL1 VSS VDD sram_AMWL_CC
XCC18 BL_18 BL__17 DIFF1_17 DIFF2_17 GDL_18 PG0_18 WL1 VSS VDD sram_AMWL_CC
XCC19 BL_19 BL__18 DIFF1_18 DIFF2_18 GDL_19 PG0_19 WL1 VSS VDD sram_AMWL_CC
XCC2 BL_2 BL__1 DIFF1_1 DIFF2_1 GDL_2 PG0_2 WL1 VSS VDD sram_AMWL_CC
XCC20 BL_20 BL__19 DIFF1_19 DIFF2_19 GDL_20 PG0_20 WL1 VSS VDD sram_AMWL_CC
XCC21 BL_21 BL__20 DIFF1_20 DIFF2_20 GDL_21 PG0_21 WL1 VSS VDD sram_AMWL_CC
XCC22 BL_22 BL__21 DIFF1_21 DIFF2_21 GDL_22 PG0_22 WL1 VSS VDD sram_AMWL_CC
XCC23 BL_23 BL__22 DIFF1_22 DIFF2_22 GDL_23 PG0_23 WL1 VSS VDD sram_AMWL_CC
XCC24 BL_24 BL__23 DIFF1_23 DIFF2_23 GDL_24 PG0_24 WL1 VSS VDD sram_AMWL_CC
XCC25 BL_25 BL__24 DIFF1_24 DIFF2_24 GDL_25 PG0_25 WL1 VSS VDD sram_AMWL_CC
XCC26 BL_26 BL__25 DIFF1_25 DIFF2_25 GDL_26 PG0_26 WL1 VSS VDD sram_AMWL_CC
XCC27 BL_27 BL__26 DIFF1_26 DIFF2_26 GDL_27 PG0_27 WL1 VSS VDD sram_AMWL_CC
XCC28 BL_28 BL__27 DIFF1_27 DIFF2_27 GDL_28 PG0_28 WL1 VSS VDD sram_AMWL_CC
XCC29 BL_29 BL__28 DIFF1_28 DIFF2_28 GDL_29 PG0_29 WL1 VSS VDD sram_AMWL_CC
XCC3 BL_3 BL__2 DIFF1_2 DIFF2_2 GDL_3 PG0_3 WL1 VSS VDD sram_AMWL_CC
XCC30 BL_30 BL__29 DIFF1_29 DIFF2_29 GDL_30 PG0_30 WL1 VSS VDD sram_AMWL_CC
XCC31 BL_31 BL__30 DIFF1_30 DIFF2_30 GDL_31 PG0_31 WL1 VSS VDD sram_AMWL_CC
XCC32 BL_32 BL__31 DIFF1_31 DIFF2_31 GDL_32 PG0_32 WL1 VSS VDD sram_AMWL_CC
XCC33 BL_33 BL__32 DIFF1_32 DIFF2_32 GDL_33 PG0_33 WL1 VSS VDD sram_AMWL_CC
XCC34 BL_34 BL__33 DIFF1_33 DIFF2_33 GDL_34 PG0_34 WL1 VSS VDD sram_AMWL_CC
XCC35 BL_35 BL__34 DIFF1_34 DIFF2_34 GDL_35 PG0_35 WL1 VSS VDD sram_AMWL_CC
XCC36 BL_36 BL__35 DIFF1_35 DIFF2_35 GDL_36 PG0_36 WL1 VSS VDD sram_AMWL_CC
XCC37 BL_37 BL__36 DIFF1_36 DIFF2_36 GDL_37 PG0_37 WL1 VSS VDD sram_AMWL_CC
XCC38 BL_38 BL__37 DIFF1_37 DIFF2_37 GDL_38 PG0_38 WL1 VSS VDD sram_AMWL_CC
XCC39 BL_39 BL__38 DIFF1_38 DIFF2_38 GDL_39 PG0_39 WL1 VSS VDD sram_AMWL_CC
XCC4 BL_4 BL__3 DIFF1_3 DIFF2_3 GDL_4 PG0_4 WL1 VSS VDD sram_AMWL_CC
XCC40 BL_40 BL__39 DIFF1_39 DIFF2_39 GDL_40 PG0_40 WL1 VSS VDD sram_AMWL_CC
XCC41 BL_41 BL__40 DIFF1_40 DIFF2_40 GDL_41 PG0_41 WL1 VSS VDD sram_AMWL_CC
XCC42 BL_42 BL__41 DIFF1_41 DIFF2_41 GDL_42 PG0_42 WL1 VSS VDD sram_AMWL_CC
XCC43 BL_43 BL__42 DIFF1_42 DIFF2_42 GDL_43 PG0_43 WL1 VSS VDD sram_AMWL_CC
XCC44 BL_44 BL__43 DIFF1_43 DIFF2_43 GDL_44 PG0_44 WL1 VSS VDD sram_AMWL_CC
XCC45 BL_45 BL__44 DIFF1_44 DIFF2_44 GDL_45 PG0_45 WL1 VSS VDD sram_AMWL_CC
XCC46 BL_46 BL__45 DIFF1_45 DIFF2_45 GDL_46 PG0_46 WL1 VSS VDD sram_AMWL_CC
XCC47 BL_47 BL__46 DIFF1_46 DIFF2_46 GDL_47 PG0_47 WL1 VSS VDD sram_AMWL_CC
XCC48 BL_48 BL__47 DIFF1_47 DIFF2_47 GDL_48 PG0_48 WL1 VSS VDD sram_AMWL_CC
XCC49 BL_49 BL__48 DIFF1_48 DIFF2_48 GDL_49 PG0_49 WL1 VSS VDD sram_AMWL_CC
XCC5 BL_5 BL__4 DIFF1_4 DIFF2_4 GDL_5 PG0_5 WL1 VSS VDD sram_AMWL_CC
XCC50 BL_50 BL__49 DIFF1_49 DIFF2_49 GDL_50 PG0_50 WL1 VSS VDD sram_AMWL_CC
XCC51 BL_51 BL__50 DIFF1_50 DIFF2_50 GDL_51 PG0_51 WL1 VSS VDD sram_AMWL_CC
XCC52 BL_52 BL__51 DIFF1_51 DIFF2_51 GDL_52 PG0_52 WL1 VSS VDD sram_AMWL_CC
XCC53 BL_53 BL__52 DIFF1_52 DIFF2_52 GDL_53 PG0_53 WL1 VSS VDD sram_AMWL_CC
XCC54 BL_54 BL__53 DIFF1_53 DIFF2_53 GDL_54 PG0_54 WL1 VSS VDD sram_AMWL_CC
XCC55 BL_55 BL__54 DIFF1_54 DIFF2_54 GDL_55 PG0_55 WL1 VSS VDD sram_AMWL_CC
XCC56 BL_56 BL__55 DIFF1_55 DIFF2_55 GDL_56 PG0_56 WL1 VSS VDD sram_AMWL_CC
XCC57 BL_57 BL__56 DIFF1_56 DIFF2_56 GDL_57 PG0_57 WL1 VSS VDD sram_AMWL_CC
XCC58 BL_58 BL__57 DIFF1_57 DIFF2_57 GDL_58 PG0_58 WL1 VSS VDD sram_AMWL_CC
XCC59 BL_59 BL__58 DIFF1_58 DIFF2_58 GDL_59 PG0_59 WL1 VSS VDD sram_AMWL_CC
XCC6 BL_6 BL__5 DIFF1_5 DIFF2_5 GDL_6 PG0_6 WL1 VSS VDD sram_AMWL_CC
XCC60 BL_60 BL__59 DIFF1_59 DIFF2_59 GDL_60 PG0_60 WL1 VSS VDD sram_AMWL_CC
XCC61 BL_61 BL__60 DIFF1_60 DIFF2_60 GDL_61 PG0_61 WL1 VSS VDD sram_AMWL_CC
XCC62 BL_62 BL__61 DIFF1_61 DIFF2_61 GDL_62 PG0_62 WL1 VSS VDD sram_AMWL_CC
XCC63 BL_63 BL__62 DIFF1_62 DIFF2_62 GDL_63 PG0_63 WL1 VSS VDD sram_AMWL_CC
XCC64 BL_64 BL__63 DIFF1_63 DIFF2_63 GDL_64 PG0_64 TL0_1 WL1 VSS VDD
+  sram_AFLMW
XCC65 BL_65 BL__64 DIFF1_64 DIFF2_64 GDL_65 PG0_65 TL0_1 VSS VDD sram_AMWL_CC
XCC66 BL_66 BL__65 DIFF1_65 DIFF2_65 GDL_66 PG0_66 TL0_1 VSS VDD sram_AMWL_CC
XCC67 BL_67 BL__66 DIFF1_66 DIFF2_66 GDL_67 PG0_67 TL0_1 VSS VDD sram_AMWL_CC
XCC68 BL_68 BL__67 DIFF1_67 DIFF2_67 GDL_68 PG0_68 TL0_1 VSS VDD sram_AMWL_CC
XCC69 BL_69 BL__68 DIFF1_68 DIFF2_68 GDL_69 PG0_69 TL0_1 VSS VDD sram_AMWL_CC
XCC7 BL_7 BL__6 DIFF1_6 DIFF2_6 GDL_7 PG0_7 WL1 VSS VDD sram_AMWL_CC
XCC70 BL_70 BL__69 DIFF1_69 DIFF2_69 GDL_70 PG0_70 TL0_1 VSS VDD sram_AMWL_CC
XCC71 BL_71 BL__70 DIFF1_70 DIFF2_70 GDL_71 PG0_71 TL0_1 VSS VDD sram_AMWL_CC
XCC72 BL_72 BL__71 DIFF1_71 DIFF2_71 GDL_72 PG0_72 TL0_1 VSS VDD sram_AMWL_CC
XCC73 BL_73 BL__72 DIFF1_72 DIFF2_72 GDL_73 PG0_73 TL0_1 VSS VDD sram_AMWL_CC
XCC74 BL_74 BL__73 DIFF1_73 DIFF2_73 GDL_74 PG0_74 TL0_1 VSS VDD sram_AMWL_CC
XCC75 BL_75 BL__74 DIFF1_74 DIFF2_74 GDL_75 PG0_75 TL0_1 VSS VDD sram_AMWL_CC
XCC76 BL_76 BL__75 DIFF1_75 DIFF2_75 GDL_76 PG0_76 TL0_1 VSS VDD sram_AMWL_CC
XCC77 BL_77 BL__76 DIFF1_76 DIFF2_76 GDL_77 PG0_77 TL0_1 VSS VDD sram_AMWL_CC
XCC78 BL_78 BL__77 DIFF1_77 DIFF2_77 GDL_78 PG0_78 TL0_1 VSS VDD sram_AMWL_CC
XCC79 BL_79 BL__78 DIFF1_78 DIFF2_78 GDL_79 PG0_79 TL0_1 VSS VDD sram_AMWL_CC
XCC8 BL_8 BL__7 DIFF1_7 DIFF2_7 GDL_8 PG0_8 WL1 VSS VDD sram_AMWL_CC
XCC80 BL_80 BL__79 DIFF1_79 DIFF2_79 GDL_80 PG0_80 TL0_1 VSS VDD sram_AMWL_CC
XCC81 BL_81 BL__80 DIFF1_80 DIFF2_80 GDL_81 PG0_81 TL0_1 VSS VDD sram_AMWL_CC
XCC82 BL_82 BL__81 DIFF1_81 DIFF2_81 GDL_82 PG0_82 TL0_1 VSS VDD sram_AMWL_CC
XCC83 BL_83 BL__82 DIFF1_82 DIFF2_82 GDL_83 PG0_83 TL0_1 VSS VDD sram_AMWL_CC
XCC84 BL_84 BL__83 DIFF1_83 DIFF2_83 GDL_84 PG0_84 TL0_1 VSS VDD sram_AMWL_CC
XCC85 BL_85 BL__84 DIFF1_84 DIFF2_84 GDL_85 PG0_85 TL0_1 VSS VDD sram_AMWL_CC
XCC86 BL_86 BL__85 DIFF1_85 DIFF2_85 GDL_86 PG0_86 TL0_1 VSS VDD sram_AMWL_CC
XCC87 BL_87 BL__86 DIFF1_86 DIFF2_86 GDL_87 PG0_87 TL0_1 VSS VDD sram_AMWL_CC
XCC88 BL_88 BL__87 DIFF1_87 DIFF2_87 GDL_88 PG0_88 TL0_1 VSS VDD sram_AMWL_CC
XCC89 BL_89 BL__88 DIFF1_88 DIFF2_88 GDL_89 PG0_89 TL0_1 VSS VDD sram_AMWL_CC
XCC9 BL_9 BL__8 DIFF1_8 DIFF2_8 GDL_9 PG0_9 WL1 VSS VDD sram_AMWL_CC
XCC90 BL_90 BL__89 DIFF1_89 DIFF2_89 GDL_90 PG0_90 TL0_1 VSS VDD sram_AMWL_CC
XCC91 BL_91 BL__90 DIFF1_90 DIFF2_90 GDL_91 PG0_91 TL0_1 VSS VDD sram_AMWL_CC
XCC92 BL_92 BL__91 DIFF1_91 DIFF2_91 GDL_92 PG0_92 TL0_1 VSS VDD sram_AMWL_CC
XCC93 BL_93 BL__92 DIFF1_92 DIFF2_92 GDL_93 PG0_93 TL0_1 VSS VDD sram_AMWL_CC
XCC94 BL_94 BL__93 DIFF1_93 DIFF2_93 GDL_94 PG0_94 TL0_1 VSS VDD sram_AMWL_CC
XCC95 BL_95 BL__94 DIFF1_94 DIFF2_94 GDL_95 PG0_95 TL0_1 VSS VDD sram_AMWL_CC
XCC96 BL_96 BL__95 DIFF1_95 DIFF2_95 GDL_96 PG0_96 TL0_1 VSS VDD sram_AMWL_CC
XCC97 BL_97 BL__96 DIFF1_96 DIFF2_96 GDL_97 PG0_97 TL0_1 VSS VDD sram_AMWL_CC
XCC98 BL_98 BL__97 DIFF1_97 DIFF2_97 GDL_98 PG0_98 TL0_1 VSS VDD sram_AMWL_CC
XCC99 BL_99 BL__98 DIFF1_98 DIFF2_98 GDL_99 PG0_99 TL0_1 VSS VDD sram_AMWL_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL1 VSS VDD
+  sram_ACCEDGE_CCMBL
.ENDS sram_AMWL_ROW128LO
****
.SUBCKT sram_ACCCAPBK BL BL_ DIFF1 GDL PG0 WL VSS VDD
** sram_ACCCAPBK: 6 flat devices **
M0 CORED CORED_ VDD VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDD CORED CORED_ VDD PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 VSS CORED_ CORED VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M3 CORED_ CORED VSS VSS NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M4 DIFF1 WL CORED VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N4/N00
M5 CORED_ WL BL_ VSS NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS sram_ACCCAPBK
****
.SUBCKT sram_ACAPBK_ROW128LE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21
+  BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33
+  BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45
+  BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57
+  BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69
+  BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81
+  BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93
+  BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104
+  BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124
+  BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5
+  DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13
+  DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21
+  DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29
+  DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37
+  DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44 DIFF1_45
+  DIFF1_46 DIFF1_47 DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52 DIFF1_53
+  DIFF1_54 DIFF1_55 DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60 DIFF1_61
+  DIFF1_62 DIFF1_63 DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68 DIFF1_69
+  DIFF1_70 DIFF1_71 DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76 DIFF1_77
+  DIFF1_78 DIFF1_79 DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84 DIFF1_85
+  DIFF1_86 DIFF1_87 DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92 DIFF1_93
+  DIFF1_94 DIFF1_95 DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100 DIFF1_101
+  DIFF1_102 DIFF1_103 DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107 DIFF1_108
+  DIFF1_109 DIFF1_110 DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114 DIFF1_115
+  DIFF1_116 DIFF1_117 DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121 DIFF1_122
+  DIFF1_123 DIFF1_124 DIFF1_125 DIFF1_126 DIFF1_127 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44
+  GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54
+  GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64
+  GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74
+  GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84
+  GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94
+  GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104
+  GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113
+  GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122
+  GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1
+  PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13
+  PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23
+  PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33
+  PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43
+  PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53
+  PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63
+  PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73
+  PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83
+  PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93
+  PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103
+  PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112
+  PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121
+  PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL
+  VSS VDD
** sram_ACAPBK_ROW128LE: 774 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 GDL_1 PG0_1 WL VSS VDD sram_ACCCAPBK
XCC10 BL_10 BL__9 DIFF1_9 GDL_10 PG0_10 WL VSS VDD sram_ACCCAPBK
XCC100 BL_100 BL__99 DIFF1_99 GDL_100 PG0_100 WL VSS VDD sram_ACCCAPBK
XCC101 BL_101 BL__100 DIFF1_100 GDL_101 PG0_101 WL VSS VDD sram_ACCCAPBK
XCC102 BL_102 BL__101 DIFF1_101 GDL_102 PG0_102 WL VSS VDD sram_ACCCAPBK
XCC103 BL_103 BL__102 DIFF1_102 GDL_103 PG0_103 WL VSS VDD sram_ACCCAPBK
XCC104 BL_104 BL__103 DIFF1_103 GDL_104 PG0_104 WL VSS VDD sram_ACCCAPBK
XCC105 BL_105 BL__104 DIFF1_104 GDL_105 PG0_105 WL VSS VDD sram_ACCCAPBK
XCC106 BL_106 BL__105 DIFF1_105 GDL_106 PG0_106 WL VSS VDD sram_ACCCAPBK
XCC107 BL_107 BL__106 DIFF1_106 GDL_107 PG0_107 WL VSS VDD sram_ACCCAPBK
XCC108 BL_108 BL__107 DIFF1_107 GDL_108 PG0_108 WL VSS VDD sram_ACCCAPBK
XCC109 BL_109 BL__108 DIFF1_108 GDL_109 PG0_109 WL VSS VDD sram_ACCCAPBK
XCC11 BL_11 BL__10 DIFF1_10 GDL_11 PG0_11 WL VSS VDD sram_ACCCAPBK
XCC110 BL_110 BL__109 DIFF1_109 GDL_110 PG0_110 WL VSS VDD sram_ACCCAPBK
XCC111 BL_111 BL__110 DIFF1_110 GDL_111 PG0_111 WL VSS VDD sram_ACCCAPBK
XCC112 BL_112 BL__111 DIFF1_111 GDL_112 PG0_112 WL VSS VDD sram_ACCCAPBK
XCC113 BL_113 BL__112 DIFF1_112 GDL_113 PG0_113 WL VSS VDD sram_ACCCAPBK
XCC114 BL_114 BL__113 DIFF1_113 GDL_114 PG0_114 WL VSS VDD sram_ACCCAPBK
XCC115 BL_115 BL__114 DIFF1_114 GDL_115 PG0_115 WL VSS VDD sram_ACCCAPBK
XCC116 BL_116 BL__115 DIFF1_115 GDL_116 PG0_116 WL VSS VDD sram_ACCCAPBK
XCC117 BL_117 BL__116 DIFF1_116 GDL_117 PG0_117 WL VSS VDD sram_ACCCAPBK
XCC118 BL_118 BL__117 DIFF1_117 GDL_118 PG0_118 WL VSS VDD sram_ACCCAPBK
XCC119 BL_119 BL__118 DIFF1_118 GDL_119 PG0_119 WL VSS VDD sram_ACCCAPBK
XCC12 BL_12 BL__11 DIFF1_11 GDL_12 PG0_12 WL VSS VDD sram_ACCCAPBK
XCC120 BL_120 BL__119 DIFF1_119 GDL_120 PG0_120 WL VSS VDD sram_ACCCAPBK
XCC121 BL_121 BL__120 DIFF1_120 GDL_121 PG0_121 WL VSS VDD sram_ACCCAPBK
XCC122 BL_122 BL__121 DIFF1_121 GDL_122 PG0_122 WL VSS VDD sram_ACCCAPBK
XCC123 BL_123 BL__122 DIFF1_122 GDL_123 PG0_123 WL VSS VDD sram_ACCCAPBK
XCC124 BL_124 BL__123 DIFF1_123 GDL_124 PG0_124 WL VSS VDD sram_ACCCAPBK
XCC125 BL_125 BL__124 DIFF1_124 GDL_125 PG0_125 WL VSS VDD sram_ACCCAPBK
XCC126 BL_126 BL__125 DIFF1_125 GDL_126 PG0_126 WL VSS VDD sram_ACCCAPBK
XCC127 BL_127 BL__126 DIFF1_126 GDL_127 PG0_127 WL VSS VDD sram_ACCCAPBK
XCC128 BL_128 BL__127 DIFF1_127 GDL_128 PG0_128 WL VSS VDD sram_ACCCAPBK
XCC13 BL_13 BL__12 DIFF1_12 GDL_13 PG0_13 WL VSS VDD sram_ACCCAPBK
XCC14 BL_14 BL__13 DIFF1_13 GDL_14 PG0_14 WL VSS VDD sram_ACCCAPBK
XCC15 BL_15 BL__14 DIFF1_14 GDL_15 PG0_15 WL VSS VDD sram_ACCCAPBK
XCC16 BL_16 BL__15 DIFF1_15 GDL_16 PG0_16 WL VSS VDD sram_ACCCAPBK
XCC17 BL_17 BL__16 DIFF1_16 GDL_17 PG0_17 WL VSS VDD sram_ACCCAPBK
XCC18 BL_18 BL__17 DIFF1_17 GDL_18 PG0_18 WL VSS VDD sram_ACCCAPBK
XCC19 BL_19 BL__18 DIFF1_18 GDL_19 PG0_19 WL VSS VDD sram_ACCCAPBK
XCC2 BL_2 BL__1 DIFF1_1 GDL_2 PG0_2 WL VSS VDD sram_ACCCAPBK
XCC20 BL_20 BL__19 DIFF1_19 GDL_20 PG0_20 WL VSS VDD sram_ACCCAPBK
XCC21 BL_21 BL__20 DIFF1_20 GDL_21 PG0_21 WL VSS VDD sram_ACCCAPBK
XCC22 BL_22 BL__21 DIFF1_21 GDL_22 PG0_22 WL VSS VDD sram_ACCCAPBK
XCC23 BL_23 BL__22 DIFF1_22 GDL_23 PG0_23 WL VSS VDD sram_ACCCAPBK
XCC24 BL_24 BL__23 DIFF1_23 GDL_24 PG0_24 WL VSS VDD sram_ACCCAPBK
XCC25 BL_25 BL__24 DIFF1_24 GDL_25 PG0_25 WL VSS VDD sram_ACCCAPBK
XCC26 BL_26 BL__25 DIFF1_25 GDL_26 PG0_26 WL VSS VDD sram_ACCCAPBK
XCC27 BL_27 BL__26 DIFF1_26 GDL_27 PG0_27 WL VSS VDD sram_ACCCAPBK
XCC28 BL_28 BL__27 DIFF1_27 GDL_28 PG0_28 WL VSS VDD sram_ACCCAPBK
XCC29 BL_29 BL__28 DIFF1_28 GDL_29 PG0_29 WL VSS VDD sram_ACCCAPBK
XCC3 BL_3 BL__2 DIFF1_2 GDL_3 PG0_3 WL VSS VDD sram_ACCCAPBK
XCC30 BL_30 BL__29 DIFF1_29 GDL_30 PG0_30 WL VSS VDD sram_ACCCAPBK
XCC31 BL_31 BL__30 DIFF1_30 GDL_31 PG0_31 WL VSS VDD sram_ACCCAPBK
XCC32 BL_32 BL__31 DIFF1_31 GDL_32 PG0_32 WL VSS VDD sram_ACCCAPBK
XCC33 BL_33 BL__32 DIFF1_32 GDL_33 PG0_33 WL VSS VDD sram_ACCCAPBK
XCC34 BL_34 BL__33 DIFF1_33 GDL_34 PG0_34 WL VSS VDD sram_ACCCAPBK
XCC35 BL_35 BL__34 DIFF1_34 GDL_35 PG0_35 WL VSS VDD sram_ACCCAPBK
XCC36 BL_36 BL__35 DIFF1_35 GDL_36 PG0_36 WL VSS VDD sram_ACCCAPBK
XCC37 BL_37 BL__36 DIFF1_36 GDL_37 PG0_37 WL VSS VDD sram_ACCCAPBK
XCC38 BL_38 BL__37 DIFF1_37 GDL_38 PG0_38 WL VSS VDD sram_ACCCAPBK
XCC39 BL_39 BL__38 DIFF1_38 GDL_39 PG0_39 WL VSS VDD sram_ACCCAPBK
XCC4 BL_4 BL__3 DIFF1_3 GDL_4 PG0_4 WL VSS VDD sram_ACCCAPBK
XCC40 BL_40 BL__39 DIFF1_39 GDL_40 PG0_40 WL VSS VDD sram_ACCCAPBK
XCC41 BL_41 BL__40 DIFF1_40 GDL_41 PG0_41 WL VSS VDD sram_ACCCAPBK
XCC42 BL_42 BL__41 DIFF1_41 GDL_42 PG0_42 WL VSS VDD sram_ACCCAPBK
XCC43 BL_43 BL__42 DIFF1_42 GDL_43 PG0_43 WL VSS VDD sram_ACCCAPBK
XCC44 BL_44 BL__43 DIFF1_43 GDL_44 PG0_44 WL VSS VDD sram_ACCCAPBK
XCC45 BL_45 BL__44 DIFF1_44 GDL_45 PG0_45 WL VSS VDD sram_ACCCAPBK
XCC46 BL_46 BL__45 DIFF1_45 GDL_46 PG0_46 WL VSS VDD sram_ACCCAPBK
XCC47 BL_47 BL__46 DIFF1_46 GDL_47 PG0_47 WL VSS VDD sram_ACCCAPBK
XCC48 BL_48 BL__47 DIFF1_47 GDL_48 PG0_48 WL VSS VDD sram_ACCCAPBK
XCC49 BL_49 BL__48 DIFF1_48 GDL_49 PG0_49 WL VSS VDD sram_ACCCAPBK
XCC5 BL_5 BL__4 DIFF1_4 GDL_5 PG0_5 WL VSS VDD sram_ACCCAPBK
XCC50 BL_50 BL__49 DIFF1_49 GDL_50 PG0_50 WL VSS VDD sram_ACCCAPBK
XCC51 BL_51 BL__50 DIFF1_50 GDL_51 PG0_51 WL VSS VDD sram_ACCCAPBK
XCC52 BL_52 BL__51 DIFF1_51 GDL_52 PG0_52 WL VSS VDD sram_ACCCAPBK
XCC53 BL_53 BL__52 DIFF1_52 GDL_53 PG0_53 WL VSS VDD sram_ACCCAPBK
XCC54 BL_54 BL__53 DIFF1_53 GDL_54 PG0_54 WL VSS VDD sram_ACCCAPBK
XCC55 BL_55 BL__54 DIFF1_54 GDL_55 PG0_55 WL VSS VDD sram_ACCCAPBK
XCC56 BL_56 BL__55 DIFF1_55 GDL_56 PG0_56 WL VSS VDD sram_ACCCAPBK
XCC57 BL_57 BL__56 DIFF1_56 GDL_57 PG0_57 WL VSS VDD sram_ACCCAPBK
XCC58 BL_58 BL__57 DIFF1_57 GDL_58 PG0_58 WL VSS VDD sram_ACCCAPBK
XCC59 BL_59 BL__58 DIFF1_58 GDL_59 PG0_59 WL VSS VDD sram_ACCCAPBK
XCC6 BL_6 BL__5 DIFF1_5 GDL_6 PG0_6 WL VSS VDD sram_ACCCAPBK
XCC60 BL_60 BL__59 DIFF1_59 GDL_60 PG0_60 WL VSS VDD sram_ACCCAPBK
XCC61 BL_61 BL__60 DIFF1_60 GDL_61 PG0_61 WL VSS VDD sram_ACCCAPBK
XCC62 BL_62 BL__61 DIFF1_61 GDL_62 PG0_62 WL VSS VDD sram_ACCCAPBK
XCC63 BL_63 BL__62 DIFF1_62 GDL_63 PG0_63 WL VSS VDD sram_ACCCAPBK
XCC64 BL_64 BL__63 DIFF1_63 GDL_64 PG0_64 WL VSS VDD sram_ACCCAPBK
XCC65 BL_65 BL__64 DIFF1_64 GDL_65 PG0_65 WL VSS VDD sram_ACCCAPBK
XCC66 BL_66 BL__65 DIFF1_65 GDL_66 PG0_66 WL VSS VDD sram_ACCCAPBK
XCC67 BL_67 BL__66 DIFF1_66 GDL_67 PG0_67 WL VSS VDD sram_ACCCAPBK
XCC68 BL_68 BL__67 DIFF1_67 GDL_68 PG0_68 WL VSS VDD sram_ACCCAPBK
XCC69 BL_69 BL__68 DIFF1_68 GDL_69 PG0_69 WL VSS VDD sram_ACCCAPBK
XCC7 BL_7 BL__6 DIFF1_6 GDL_7 PG0_7 WL VSS VDD sram_ACCCAPBK
XCC70 BL_70 BL__69 DIFF1_69 GDL_70 PG0_70 WL VSS VDD sram_ACCCAPBK
XCC71 BL_71 BL__70 DIFF1_70 GDL_71 PG0_71 WL VSS VDD sram_ACCCAPBK
XCC72 BL_72 BL__71 DIFF1_71 GDL_72 PG0_72 WL VSS VDD sram_ACCCAPBK
XCC73 BL_73 BL__72 DIFF1_72 GDL_73 PG0_73 WL VSS VDD sram_ACCCAPBK
XCC74 BL_74 BL__73 DIFF1_73 GDL_74 PG0_74 WL VSS VDD sram_ACCCAPBK
XCC75 BL_75 BL__74 DIFF1_74 GDL_75 PG0_75 WL VSS VDD sram_ACCCAPBK
XCC76 BL_76 BL__75 DIFF1_75 GDL_76 PG0_76 WL VSS VDD sram_ACCCAPBK
XCC77 BL_77 BL__76 DIFF1_76 GDL_77 PG0_77 WL VSS VDD sram_ACCCAPBK
XCC78 BL_78 BL__77 DIFF1_77 GDL_78 PG0_78 WL VSS VDD sram_ACCCAPBK
XCC79 BL_79 BL__78 DIFF1_78 GDL_79 PG0_79 WL VSS VDD sram_ACCCAPBK
XCC8 BL_8 BL__7 DIFF1_7 GDL_8 PG0_8 WL VSS VDD sram_ACCCAPBK
XCC80 BL_80 BL__79 DIFF1_79 GDL_80 PG0_80 WL VSS VDD sram_ACCCAPBK
XCC81 BL_81 BL__80 DIFF1_80 GDL_81 PG0_81 WL VSS VDD sram_ACCCAPBK
XCC82 BL_82 BL__81 DIFF1_81 GDL_82 PG0_82 WL VSS VDD sram_ACCCAPBK
XCC83 BL_83 BL__82 DIFF1_82 GDL_83 PG0_83 WL VSS VDD sram_ACCCAPBK
XCC84 BL_84 BL__83 DIFF1_83 GDL_84 PG0_84 WL VSS VDD sram_ACCCAPBK
XCC85 BL_85 BL__84 DIFF1_84 GDL_85 PG0_85 WL VSS VDD sram_ACCCAPBK
XCC86 BL_86 BL__85 DIFF1_85 GDL_86 PG0_86 WL VSS VDD sram_ACCCAPBK
XCC87 BL_87 BL__86 DIFF1_86 GDL_87 PG0_87 WL VSS VDD sram_ACCCAPBK
XCC88 BL_88 BL__87 DIFF1_87 GDL_88 PG0_88 WL VSS VDD sram_ACCCAPBK
XCC89 BL_89 BL__88 DIFF1_88 GDL_89 PG0_89 WL VSS VDD sram_ACCCAPBK
XCC9 BL_9 BL__8 DIFF1_8 GDL_9 PG0_9 WL VSS VDD sram_ACCCAPBK
XCC90 BL_90 BL__89 DIFF1_89 GDL_90 PG0_90 WL VSS VDD sram_ACCCAPBK
XCC91 BL_91 BL__90 DIFF1_90 GDL_91 PG0_91 WL VSS VDD sram_ACCCAPBK
XCC92 BL_92 BL__91 DIFF1_91 GDL_92 PG0_92 WL VSS VDD sram_ACCCAPBK
XCC93 BL_93 BL__92 DIFF1_92 GDL_93 PG0_93 WL VSS VDD sram_ACCCAPBK
XCC94 BL_94 BL__93 DIFF1_93 GDL_94 PG0_94 WL VSS VDD sram_ACCCAPBK
XCC95 BL_95 BL__94 DIFF1_94 GDL_95 PG0_95 WL VSS VDD sram_ACCCAPBK
XCC96 BL_96 BL__95 DIFF1_95 GDL_96 PG0_96 WL VSS VDD sram_ACCCAPBK
XCC97 BL_97 BL__96 DIFF1_96 GDL_97 PG0_97 WL VSS VDD sram_ACCCAPBK
XCC98 BL_98 BL__97 DIFF1_97 GDL_98 PG0_98 WL VSS VDD sram_ACCCAPBK
XCC99 BL_99 BL__98 DIFF1_98 GDL_99 PG0_99 WL VSS VDD sram_ACCCAPBK
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSS VDD
+  sram_ACCEDGE_CCMBL
.ENDS sram_ACAPBK_ROW128LE
****
.SUBCKT sram_ACABL128X64TT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21
+  BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33
+  BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45
+  BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57
+  BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69
+  BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81
+  BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93
+  BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104
+  BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124
+  BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89
+  GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99
+  GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108
+  GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117
+  GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126
+  GDL_127 GDL_128 MBL PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49
+  PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59
+  PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69
+  PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79
+  PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89
+  PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99
+  PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108
+  PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117
+  PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126
+  PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 VSS VDD
** sram_ACABL128X64TT: 51858 flat devices **
XCC_ROW0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_683 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_685 PDIFF_687 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_0 VSS VDD sram_ACC_ROW128LE
XCC_ROW1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_683 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_685 PDIFF_689 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_1 VSS VDD sram_ACC_ROW128LO
XCC_ROW10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_595 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_597 PDIFF_599 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_10 VSS VDD sram_ACC_ROW128LE
XCC_ROW11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_595 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_597 PDIFF_601 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_11 VSS VDD sram_ACC_ROW128LO
XCC_ROW12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_607 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_609 PDIFF_601 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_12 VSS VDD sram_ACC_ROW128LE
XCC_ROW13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_607 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_609 PDIFF_613 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_13 VSS VDD sram_ACC_ROW128LO
XCC_ROW14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_623 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_625 PDIFF_613 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_14 VSS VDD sram_ACC_ROW128LE
XCC_ROW15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_623 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_625 PDIFF_631 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_15 VSS VDD sram_ACC_ROW128LO
XCC_ROW16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_641 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_643 PDIFF_631 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_16 VSS VDD sram_ACC_ROW128LE
XCC_ROW17 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_641 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_643 PDIFF_649 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_17 VSS VDD sram_ACC_ROW128LO
XCC_ROW18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_659 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_661 PDIFF_649 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_18 VSS VDD sram_ACC_ROW128LE
XCC_ROW19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_659 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_661 PDIFF_667 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_19 VSS VDD sram_ACC_ROW128LO
XCC_ROW2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_691 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_693 PDIFF_689 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_2 VSS VDD sram_ACC_ROW128LE
XCC_ROW20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF PDIFF_667 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_20 VSS VDD sram_ACC_ROW128LE
XCC_ROW21 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49
+  PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59
+  PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69
+  PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79
+  PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89
+  PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99
+  PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108
+  PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117
+  PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126
+  PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_21 VSS VDD sram_ACC_ROW128LO
XCC_ROW22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_11 PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_22 VSS VDD sram_ACC_ROW128LE
XCC_ROW23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_11 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_23 VSS VDD sram_ACC_ROW128LO
XCC_ROW24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_29 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_24 VSS VDD sram_ACC_ROW128LE
XCC_ROW25 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_29 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_25 VSS VDD sram_ACC_ROW128LO
XCC_ROW26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_47 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_26 VSS VDD sram_ACC_ROW128LE
XCC_ROW27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_47 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_27 VSS VDD sram_ACC_ROW128LO
XCC_ROW28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_61 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_28 VSS VDD sram_ACC_ROW128LE
XCC_ROW29 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_61 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_29 VSS VDD sram_ACC_ROW128LO
XCC_ROW3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_691 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_693 PDIFF_695 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_3 VSS VDD sram_ACC_ROW128LO
XCC_ROW30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_603 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_605 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_30 VSS VDD sram_ACC_ROW128LE
XCC_ROW31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_603 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_605 PDIFF_611 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_31 VSS VDD sram_ACC_ROW128LO
XCC_ROW32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_615 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_617 PDIFF_611 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_32 VSS VDD sram_ACC_ROW128LE
XCC_ROW33 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_615 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_617 PDIFF_627 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_33 VSS VDD sram_ACC_ROW128LO
XCC_ROW34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_633 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_635 PDIFF_627 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_34 VSS VDD sram_ACC_ROW128LE
XCC_ROW35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_633 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_635 PDIFF_645 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_35 VSS VDD sram_ACC_ROW128LO
XCC_ROW36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
